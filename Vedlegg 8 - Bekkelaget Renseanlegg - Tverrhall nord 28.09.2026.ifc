Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcFlowSegment: Round Duct:Sirkulær kanal Galv (254)
Name (Round Duct:Sirkulær kanal Galv:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2712251 | 1871.95 | 3600.001.04 Tilluft: 8
2742126 | 200 | 3600.001.04 Tilluft: 8
2748731 | 4855 | 3600.001.04 Tilluft: 8
2762515 | 48027.7 | 3600.001.04 Tilluft: 8
2762517 | 46.3403 | 3600.001.04 Tilluft: 8
2762616 | 5643.61 | 3600.001.04 Tilluft: 8
2790195 | 3194.06 | 3600.001.04 Tilluft: 8
2801298 | 1405.43 | 3600.001.04 Tilluft: 8
2801326 | 1379.49 | 3600.001.04 Tilluft: 8
2801620 | 160.454 | 3600.001.04 Tilluft: 8
2802191 | 132.616 | 3600.001.04 Tilluft: 8
2843052 | 4348.2 | 3600.001.04 Tilluft: 8
2848417 | 21030.7 | 3600.001.04 Tilluft: 8
2850054 | 2241.08 | 3600.001.01 Inntak: 13
2850099 | 1025 | 3600.001.01 Inntak: 7
2851564 | 5498.67 | 3600.001.04 Tilluft: 8
2852045 | 846.899 | 3600.001.04 Tilluft: 8

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (81)
In: 0-Havnivå
Type - Description: Sirkulær kanal syrefast; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal SF 1; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2203930 | 6062.92 | 3600.001.08 Spesialavtrekk: 25
2204800 | 922.5 | 3600.001.08 Spesialavtrekk: 21
2271470 | 11908.5 | 3600.001.05 Avtrekk: 10
2274780 | 24889 | 3600.001.05 Avtrekk: 10
2277505 | 3210.99 | 3600.001.05 Avtrekk: 7
2278088 | 990.986 | 3600.001.05 Avtrekk: 10
2278123 | 3118.32 | 3600.001.05 Avtrekk: 10
2278771 | 220 | 3600.001.05 Avtrekk: 10
2279424 | 1850.4 | 3600.001.08 Spesialavtrekk: 25
2279440 | 3915.79 | 3600.001.08 Spesialavtrekk: 25
2279620 | 480 | 3600.001.08 Spesialavtrekk: 25
2279718 | 1831.19 | 3600.001.08 Spesialavtrekk: 25
2279738 | 44677.3 | 3600.001.08 Spesialavtrekk: 25
2298738 | 3494.49 | 3600.001.08 Spesialavtrekk: 25
2303056 | 170.677 | 3600.001.08 Spesialavtrekk: 25
2303090 | 7839.99 | 3600.001.08 Spesialavtrekk: 25
2303175 | 2051.31 | 3600.001.08 Spesialavtrekk: 25
2303203 | 7140 | 3600.001.08 Spesialavtrekk: 25
2303446 | 510.491 | 3600.001.05 Avtrekk: 7
2303473 | 575 | 3600.001.08 Spesialavtrekk: 25
2303853 | 2830 | 3600.001.08 Spesialavtrekk: 25
2303997 | 1022.5 | 3600.001.08 Spesialavtrekk: 24
2326999 | 2674.07 | 3600.001.08 Spesialavtrekk: 25
2334226 | 1001.74 | 3600.001.08 Spesialavtrekk: 25
2334241 | 3097.59 | 3600.001.08 Spesialavtrekk: 25
2334819 | 5785 | 3600.001.08 Spesialavtrekk: 25
2334968 | 6146.64 | 3600.001.08 Spesialavtrekk: 25
2335207 | 870.414 | 3600.001.08 Spesialavtrekk: 25
2335615 | 120.625 | 3600.001.08 Spesialavtrekk: 25
2367311 | 447.34 | 3600.001.08 Spesialavtrekk: 25
2368159 | 737.514 | 3600.001.08 Spesialavtrekk: 25
2368161 | 50.5867 | 3600.001.08 Spesialavtrekk: 25
2368171 | 447.34 | 3600.001.08 Spesialavtrekk: 25
2368454 | 1876.83 | 3600.001.08 Spesialavtrekk: 25
2368496 | 725.726 | 3600.001.08 Spesialavtrekk: 25
2368547 | 435 | 3600.001.08 Spesialavtrekk: 25
2369777 | 845.667 | 3600.001.08 Spesialavtrekk: 25
2369797 | 736.788 | 3600.001.08 Spesialavtrekk: 25
2370309 | 626.522 | 3600.001.08 Spesialavtrekk: 25
2370449 | 1048.44 | 3600.001.08 Spesialavtrekk: 25
2370618 | 390.491 | 3600.001.05 Avtrekk: 10
2371009 | 789.759 | 3600.001.08 Spesialavtrekk: 25
2373397 | 870.414 | 3600.001.08 Spesialavtrekk: 25
2373399 | 220.262 | 3600.001.08 Spesialavtrekk: 25
2373409 | 447.34 | 3600.001.08 Spesialavtrekk: 25
2373425 | 737.514 | 3600.001.08 Spesialavtrekk: 25
2373427 | 196.233 | 3600.001.08 Spesialavtrekk: 25
2373437 | 447.34 | 3600.001.08 Spesialavtrekk: 25
2373452 | 768.2 | 3600.001.08 Spesialavtrekk: 25
2390876 | 337.181 | 3600.001.08 Spesialavtrekk: 25
2390965 | 936.985 | 3600.001.08 Spesialavtrekk: 25
2391317 | 815.4 | 3600.001.08 Spesialavtrekk: 25
2391361 | 1621.69 | 3600.001.08 Spesialavtrekk: 25
2391771 | 653.785 | 3600.001.08 Spesialavtrekk: 25
2391775 | 437.616 | 3600.001.08 Spesialavtrekk: 25
2391779 | 1069.11 | 3600.001.08 Spesialavtrekk: 25
2419578 | 1245 | 3600.001.08 Spesialavtrekk: 25
2419593 | 22200 | 3600.001.08 Spesialavtrekk: 25
2471690 | 6062.92 | 3600.001.08 Spesialavtrekk: 25
2471773 | 580 | 3600.001.08 Spesialavtrekk: 25
2484823 | 43399 | 3600.001.08 Spesialavtrekk: 25
2484904 | 27308.4 | 3600.001.05 Avtrekk: 7
2511199 | 1287.63 | 3600.001.05 Avtrekk: 10
2513198 | 563.361 | 3600.001.08 Spesialavtrekk: 25
2578244 | 5121.07 | 3600.001.05 Avtrekk: 10
2587783 | 790 | 3600.001.05 Avtrekk: 7
2587792 | 790 | 3600.001.05 Avtrekk: 7
2587801 | 1090 | 3600.001.05 Avtrekk: 7
2599478 | 3306.56 | 3600.001.05 Avtrekk: 10
2599716 | 3306.56 | 3600.001.05 Avtrekk: 7
2767590 | 251.182 | 3600.001.08 Spesialavtrekk: 25
2767596 | 560.796 | 3600.001.08 Spesialavtrekk: 25
2770080 | 603.6 | 3600.001.08 Spesialavtrekk: 25
2801289 | 3907.08 | 3600.001.08 Spesialavtrekk: 25
2801308 | 3319.06 | 3600.001.08 Spesialavtrekk: 25
2801378 | 1979.44 | 3600.001.05 Avtrekk: 10
2812563 | 1408.47 | 3600.001.08 Spesialavtrekk: 25
2818797 | 2500 | 3600.001.05 Avtrekk: 7
2834137 | 134.472 | 3600.001.08 Spesialavtrekk: 25
2834159 | 87.2269 | 3600.001.08 Spesialavtrekk: 25
2840376 | 762.247 | 3600.001.08 Spesialavtrekk: 25

# IfcFlowTerminal: CYHA:CYHA-1000, CYHA:CYHA-1000:2439826
In: 0-Havnivå
Type - Description: External louvre designed for supply or exhaust air flow.; Material: 3600.001 Inntak
Pset_DistributionFlowElementCommon - Reference: CYHA-1000; sets with these values: 2
Group: 3600.001.01 Inntak: 7

# IfcFlowTerminal: CYHA:CYHA-1500, CYHA:CYHA-1500:2433396
In: 0-Havnivå
Type - Description: External louvre, designed for supply or exhaust air flow.; Material: 3600.001 Inntak
Pset_DistributionFlowElementCommon - Reference: CYHA-1500; sets with these values: 2
Group: 3600.001.01 Inntak: 13

# IfcFlowTerminal: CYHA:CYHA-315, CYHA:CYHA-315:2447087
In: 0-Havnivå
Type - Description: External louvre, designed for supply or exhaust air flow.; Material: 3600.001 Inntak
Pset_DistributionFlowElementCommon - Reference: CYHA-315; sets with these values: 2
Group: 3600.001.01 Inntak: 8

# IfcFlowTerminal: EKO-SSG Circular:EKO-SSG-250 (16)
In: 0-Havnivå
Type - Description: Circular burglary resistant louvre; Material: MC_157_161_170_0_50
Pset_DistributionFlowElementCommon - Reference: EKO-SSG-250; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (EKO-SSG Circular:EKO-SSG-250:...)
2422282
2422429
2422466
2422491
2422516
2422541
2422568
2422593
2422618
2422645
2422670
2422697
2422722
2422747
2422772
2422797

# IfcFlowTerminal: Netting-A:Netting-A-125 (4)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-125; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (Netting-A:Netting-A-125:...)
2369461
2369463
2373439
2373441

# IfcFlowTerminal: Netting-A:Netting-A-160 (4)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-160; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (Netting-A:Netting-A-160:...)
2391243
2391762
2391765
2391766

# IfcFlowTerminal: Netting-T:Netting-T-630, Netting-T:Netting-T-630:2398378
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-T-630; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcFlowTerminal: SI-T_V:SI-T/V-0612 (2)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-0612; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-0612:...)
2359661
2359665

# IfcFlowTerminal: SI-T_V:SI-T/V-1212 Tverrhall (12)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1212 Tverrhall; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1212 Tverrhall:...)
2417758
2418171
2418191
2418509
2418542
2426108
2426128
2426148
2426168
2426188
2426208
2426228

# IfcFlowTerminal: TDT Narrow beam:TDT-315 Narrow beam (3)
In: 0-Havnivå
Type - Description: Jet nozzles; Material: MC_236_236_231_0_50
Pset_DistributionFlowElementCommon - Reference: TDT-315 Narrow beam; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (TDT Narrow beam:TDT-315 Narrow beam:...)
2491712
2491714
2491715
