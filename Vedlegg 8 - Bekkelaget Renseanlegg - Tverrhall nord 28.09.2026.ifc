Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c04e82b7-d741-4bb0-b665-850c62e824b8, VersionGUID: 5e7f8b49-13e5-45dc-8312-d325b395ee56, NumberOfSaves: 1855], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Bekkelaget Renseanlegg - Tverrhall nord.ifc
Time: 2026-09-18T15:16:07+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENU) - 26.4.10.8

# IfcProject, 52502296
LongName: Bekkelaget RA - Oppgradering 2000-anlegget; Phase: ---

# IfcSite, Default
RefLatitude: 49, 0, 24, 428900; RefLongitude: 9, 7, 59, 338362; RefElevation: 0 mm

# IfcBuilding, Bygning (endres i Project Information)
LongName: Bygning (endres i Project Information)
Pset_BuildingCommon - NumberOfStoreys: 11

# IfcBuildingStorey (11)
In: Bygning (endres i Project Information)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
+00,00 | +00,00 | -8.84387e-11
Plan 01 | Plan 01 | 0
0-Havnivå | 0-Havnivå | 0
PLAN +2,50 | PLAN +2,50 | 2500
Plan 02 | Plan 02 | 3500
PLAN +5,00 | PLAN +5,00 | 5000
Plan 03 | Plan 03 | 7000
PLAN +7,80 | PLAN +7,80 | 7800
PLAN +10,50 | PLAN +10,50 | 10500
PLAN +13,40 | PLAN +13,40 | 13400
PLAN +16,00 | PLAN +16,00 | 16000

# IfcBuildingElementProxy: Aggregat nytt Bekkelaget:Aggregat nytt Bekkelaget, Aggregat nytt Bekkelaget:Aggregat nytt Bekkelaget:2348577
In: 0-Havnivå
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Aggregat nytt Bekkelaget; sets with these values: 2

# IfcBuildingElementProxy: Avkastsvifta2:Avkastsvifta2, Avkastsvifta2:Avkastsvifta2:2284688
In: 0-Havnivå
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Avkastsvifta2; sets with these values: 2

# IfcBuildingElementProxy: Axial Vfta:AW-650 D6-2-EX Axial fan ATEX, Axial Vfta:AW-650 D6-2-EX Axial fan ATEX:2805089
In: 0-Havnivå
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: AW-650 D6-2-EX Axial fan ATEX; sets with these values: 2

# IfcBuildingElementProxy: Brannspjeld:FK2-EU/1300x600x305 (4)
In: 0-Havnivå
Type - Description: Fire Damper for diverse applications; Material: MC_197_197_197_0_50, MC_191_191_191_0_50
Pset_BuildingElementProxyCommon - Reference: FK2-EU/1300x600x305; sets with these values: 2
Name (Brannspjeld:FK2-EU/1300x600x305:...) | Group
2818833 | 3600.001.05 Avtrekk: 11
2826470 | 3600.001.08 Spesialavtrekk: 29
2849293 | 3600.001.08 Spesialavtrekk: 30
2849776 | 3600.001.05 Avtrekk: 12

# IfcBuildingElementProxy: Brannspjeld:FK2-EU/800x800x305 (4)
In: 0-Havnivå
Type - Description: Fire Damper for diverse applications; Material: MC_197_197_197_0_50, MC_191_191_191_0_50
Pset_BuildingElementProxyCommon - Reference: FK2-EU/800x800x305; sets with these values: 2
Name (Brannspjeld:FK2-EU/800x800x305:...)
2762909
2763469
2763678
2802844

# IfcBuildingElementProxy: DRU:DRU 1000 (8)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 1000; sets with these values: 2
Name (DRU:DRU 1000:...) | Group
2587786 | 3600.001.05 Avtrekk: 7
2587795 | 3600.001.05 Avtrekk: 10
2587813 | 3600.001.05 Avtrekk: 7
2790198 | 3600.001.04 Tilluft: 8
2801329 | 3600.001.04 Tilluft: 8
2801381 | 3600.001.05 Avtrekk: 10
2801623 | 3600.001.04 Tilluft: 8
2802194 | 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: DRU:DRU 500, DRU:DRU 500:2598154
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 500; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: DRU:DRU 800 (2)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Spesialavtrekk
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Pset_BuildingElementProxyCommon - Reference: DRU 800; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (DRU:DRU 800:...)
2801292
2801311

# IfcBuildingElementProxy: FDMA-PM _80:FDMA-PM-1000-.80 (3)
In: 0-Havnivå
Type - Material: MC_191_191_191_0_50, MC_255_255_255_0_50, MC_0_0_0_0_50
Pset_BuildingElementProxyCommon - Reference: FDMA-PM-1000-.80; sets with these values: 2
Name (FDMA-PM _80:FDMA-PM-1000-.80:...) | Group
2812566 | 3600.001.08 Spesialavtrekk: 25
2847444 | 3600.001.04 Tilluft: 8
2850103 | 3600.001.01 Inntak: 7

# IfcBuildingElementProxy: FK2-EU__x_x305 24V:FK2-EU/1500x800x305 (8)
In: 0-Havnivå
Type - Description: Fire Damper for diverse applications; Material: MC_197_197_197_0_50, MC_191_191_191_0_50
Pset_BuildingElementProxyCommon - Reference: FK2-EU/1500x800x305; sets with these values: 2
Name (FK2-EU__x_x305 24V:FK2-EU/1500x800x305:...) | Group
2847783 | 3600.001.04 Tilluft: 5
2847884 | 3600.001.04 Tilluft: 10
2848328 | 3600.001.04 Tilluft: 12
2848329 | 3600.001.04 Tilluft: 15
2848730 | 3600.001.02 Avkast: 6
2848774 | 3600.001.02 Avkast: 3
2850052 | 3600.001.01 Inntak: 28
2850167 | 3600.001.01 Inntak: 29

# IfcBuildingElementProxy: FKR-EU_DE___ZXX:FKR-EU/DE/630/ZXX, FKR-EU_DE___ZXX:FKR-EU/DE/630/ZXX:2851567
In: 0-Havnivå
Type - Description: Fire damper; Material: 3600.001 Tilluft
Type - Pset_ManufacturerTypeInformation - Manufacturer: TROX
Pset_BuildingElementProxyCommon - Reference: FKR-EU/DE/630/ZXX; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: FKR-EU_DE___ZXX:Hurtig_lukke_spjeld, FKR-EU_DE___ZXX:Hurtig_lukke_spjeld:2425714
In: 0-Havnivå
Type - Description: Fire damper; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: Hurtig_lukke_spjeld; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: FKRS-SK_Z45B:FKRS-SK/250/Z45B (2)
In: 0-Havnivå
Type - Description: Fire damper; Material: MC_205_205_205_0_50, MC_191_191_191_0_50
Pset_BuildingElementProxyCommon - Reference: FKRS-SK/250/Z45B; sets with these values: 2
Name (FKRS-SK_Z45B:FKRS-SK/250/Z45B:...) | Group
2840383 | 3600.001.08 Spesialavtrekk: 25
2852048 | 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: IRIS:IRIS-125 (4)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: IRIS-125; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (IRIS:IRIS-125:...)
2369790
2369800
2373448
2373454

# IfcBuildingElementProxy: IRIS:IRIS-160 (4)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: IRIS-160; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (IRIS:IRIS-160:...)
2369780
2391774
2391778
2391782

# IfcBuildingElementProxy: IRIS:IRIS-200 (2)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-200; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (IRIS:IRIS-200:...)
2416658
2416666

# IfcBuildingElementProxy: IRIS:IRIS-250 (18)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-250; sets with these values: 2
Name (IRIS:IRIS-250:...) | Group
2416374 | 3600.001.04 Tilluft: 8
2422269 | 3600.001.05 Avtrekk: 7
2422428 | 3600.001.05 Avtrekk: 7
2422465 | 3600.001.05 Avtrekk: 7
2422490 | 3600.001.05 Avtrekk: 7
2422515 | 3600.001.05 Avtrekk: 7
2422540 | 3600.001.05 Avtrekk: 7
2422567 | 3600.001.05 Avtrekk: 7
2422592 | 3600.001.05 Avtrekk: 7
2422617 | 3600.001.05 Avtrekk: 7
2422644 | 3600.001.05 Avtrekk: 7
2422669 | 3600.001.05 Avtrekk: 7
2422696 | 3600.001.05 Avtrekk: 7
2422721 | 3600.001.05 Avtrekk: 7
2422746 | 3600.001.05 Avtrekk: 7
2422771 | 3600.001.05 Avtrekk: 7
2422796 | 3600.001.05 Avtrekk: 7
2513348 | 3600.001.08 Spesialavtrekk: 25

# IfcBuildingElementProxy: IRIS:IRIS-315 Tverrhall (15)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-315 Tverrhall; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (IRIS:IRIS-315 Tverrhall:...)
2416490
2416498
2416506
2417794
2418174
2418194
2418512
2418545
2426111
2426131
2426151
2426171
2426191
2426211
2426231

# IfcBuildingElementProxy: Kanal vifte_4:Kanal vifte_4, Kanal vifte_4:Kanal vifte_4:2530905
In: 0-Havnivå
Type - Material: RGB 202-209-238, RGB 128-128-128, RGB 064-064-064, RGB 199-194-189
Pset_BuildingElementProxyCommon - Reference: Kanal vifte_4; sets with these values: 2

# IfcBuildingElementProxy: Kanalvifte:KVK Silent 250 EC 50Hz, Kanalvifte:KVK Silent 250 EC 50Hz:2767560
In: 0-Havnivå
Type - Description: N/A; Material: MC_187_187_187_0_50, MC_77_38_38_0_50
Pset_BuildingElementProxyCommon - Reference: KVK Silent 250 EC 50Hz; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25

# IfcBuildingElementProxy: LKR-900:LKR-250-900 (2)
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: LKR-250-900; sets with these values: 2
Name (LKR-900:LKR-250-900:...) | Group
2416362 | 3600.001.04 Tilluft: 8
2767569 | 3600.001.08 Spesialavtrekk: 25

# IfcBuildingElementProxy: Lydfelle_1700:Lydfelle_1700 (2)
In: 0-Havnivå
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Lydfelle_1700; sets with these values: 2
Name (Lydfelle_1700:Lydfelle_1700:...)
2486011
2806364

# IfcCovering: Duct Insulation:Brann isolasjon (9)
Type - Description: BIB.001 - Term.isol. Lamellmatte 25mm; PredefinedType: INSULATION
Type - Pset_ConcreteElementGeneral - FireRating: -
Type - Pset_CoveringCommon - FireRating: -; AcousticRating: -
Material: 3600.001 Tilluft
Pset_CoveringCommon - Reference: Brann isolasjon
Pset_QuantityTakeOff - Reference: Brann isolasjon
Name (Duct Insulation:Brann isolasjon:...) | In
2417619 | PLAN +7,80
2417620 | PLAN +7,80
2417621 | PLAN +7,80
2417622 | PLAN +7,80
2425748 | PLAN +10,50
2496667 | PLAN +10,50
2496668 | PLAN +10,50
2496669 | PLAN +10,50
2598277 | PLAN +7,80

# IfcCovering: Duct Insulation:Cellegummi (31)
Type - PredefinedType: INSULATION
Type - Pset_ConcreteElementGeneral - FireRating: -
Type - Pset_CoveringCommon - FireRating: -; AcousticRating: -
Material: 3600.001 Inntak
Pset_CoveringCommon - Reference: Cellegummi
Pset_QuantityTakeOff - Reference: Cellegummi
Name (Duct Insulation:Cellegummi:...) | In
2420362 | PLAN +10,50
2420460 | PLAN +7,80
2420461 | PLAN +7,80
2420462 | PLAN +7,80
2420463 | PLAN +7,80
2420464 | PLAN +7,80
2420465 | PLAN +7,80
2420466 | PLAN +7,80
2420467 | PLAN +7,80
2420469 | PLAN +10,50
2420470 | PLAN +10,50
2420471 | PLAN +10,50
2420472 | PLAN +5,00
2420473 | Plan 03
2420476 | Plan 02
2420477 | Plan 02
2420478 | Plan 02
2420479 | Plan 02
2530116 | Plan 02
2530117 | PLAN +7,80
2530118 | PLAN +7,80
2530119 | PLAN +10,50
2530120 | PLAN +10,50
2530121 | PLAN +10,50
2530122 | Plan 02
2530123 | PLAN +10,50
2530124 | PLAN +10,50
2770251 | Plan 02
2770326 | PLAN +7,80
2850102 | Plan 02
2850110 | Plan 02

# IfcCovering: Duct Insulation:QZB.011 (72)
Type - Description: QZB.011 - Brannmatte EI60 (o→i) 60mm kun for tilluft; PredefinedType: INSULATION
Type - Pset_ConcreteElementGeneral - FireRating: EI60
Type - Pset_CoveringCommon - FireRating: EI60; AcousticRating: -
Pset_CoveringCommon - Reference: QZB.011
Pset_QuantityTakeOff - Reference: QZB.011
Name (Duct Insulation:QZB.011:...) | In | Material
2420349 | PLAN +7,80 | 3600.001 Inntak
2420350 | PLAN +10,50 | 3600.001 Inntak
2420351 | PLAN +10,50 | 3600.001 Inntak
2420359 | Plan 02 | 3600.001 Inntak
2420446 | PLAN +5,00 | 3600.001 Inntak
2420447 | PLAN +5,00 | 3600.001 Inntak
2420448 | PLAN +5,00 | 3600.001 Inntak
2420449 | Plan 03 | 3600.001 Inntak
2420450 | PLAN +7,80 | 3600.001 Inntak
2530125 | PLAN +10,50 | 3600.001 Inntak
2530126 | PLAN +10,50 | 3600.001 Inntak
2530127 | Plan 02 | 3600.001 Inntak
2530128 | PLAN +10,50 | 3600.001 Inntak
2530129 | Plan 02 | 3600.001 Inntak
2762876 | PLAN +10,50 | 3600.001 Tilluft
2762890 | PLAN +7,80 | 3600.001 Tilluft
2762899 | PLAN +13,40 | 3600.001 Tilluft
2767979 | PLAN +10,50 | 3600.001 Tilluft
2833634 | PLAN +10,50 | 3600.001 Tilluft
2848205 | PLAN +10,50 | 3600.001 Tilluft
2850056 | Plan 02 | 3600.001 Inntak
2852066 | PLAN +10,50 | 3600.001 Tilluft
2852067 | PLAN +10,50 | 3600.001 Tilluft
2852068 | PLAN +10,50 | 3600.001 Tilluft
2852069 | PLAN +10,50 | 3600.001 Tilluft
2852070 | PLAN +10,50 | 3600.001 Tilluft
2852071 | PLAN +10,50 | 3600.001 Tilluft
2852072 | PLAN +10,50 | 3600.001 Tilluft
2852079 | PLAN +10,50 | 3600.001 Tilluft
2852088 | PLAN +10,50 | 3600.001 Tilluft
2852089 | PLAN +10,50 | 3600.001 Tilluft
2852090 | PLAN +10,50 | 3600.001 Tilluft
2852091 | PLAN +10,50 | 3600.001 Tilluft
2852094 | PLAN +10,50 | 3600.001 Tilluft
2852954 | PLAN +10,50 | 3600.001 Tilluft
2852955 | PLAN +10,50 | 3600.001 Tilluft
2852956 | PLAN +10,50 | 3600.001 Tilluft
2852957 | PLAN +10,50 | 3600.001 Tilluft
2852958 | PLAN +7,80 | 3600.001 Tilluft
2852959 | PLAN +10,50 | 3600.001 Tilluft
2852960 | PLAN +7,80 | 3600.001 Tilluft
2852961 | PLAN +10,50 | 3600.001 Tilluft
2852962 | PLAN +7,80 | 3600.001 Tilluft
2852963 | PLAN +10,50 | 3600.001 Tilluft
2852964 | PLAN +10,50 | 3600.001 Tilluft
2852965 | PLAN +10,50 | 3600.001 Tilluft
2852966 | PLAN +13,40 | 3600.001 Tilluft
2852967 | PLAN +13,40 | 3600.001 Tilluft
2852968 | PLAN +13,40 | 3600.001 Tilluft
2852969 | PLAN +13,40 | 3600.001 Tilluft
2852970 | PLAN +10,50 | 3600.001 Tilluft
2852971 | PLAN +10,50 | 3600.001 Tilluft
2852972 | PLAN +10,50 | 3600.001 Tilluft
2852973 | PLAN +10,50 | 3600.001 Tilluft
2852974 | PLAN +10,50 | 3600.001 Tilluft
2852975 | PLAN +10,50 | 3600.001 Tilluft
2852976 | PLAN +10,50 | 3600.001 Tilluft
2852977 | PLAN +10,50 | 3600.001 Tilluft
2852978 | PLAN +10,50 | 3600.001 Tilluft
2852979 | PLAN +10,50 | 3600.001 Tilluft
2852980 | PLAN +10,50 | 3600.001 Tilluft
2852981 | PLAN +10,50 | 3600.001 Tilluft
2852982 | PLAN +10,50 | 3600.001 Tilluft
2852983 | PLAN +10,50 | 3600.001 Tilluft
2852984 | PLAN +10,50 | 3600.001 Tilluft
2852985 | PLAN +10,50 | 3600.001 Tilluft
2852986 | PLAN +7,80 | 3600.001 Tilluft
2852987 | PLAN +13,40 | 3600.001 Tilluft
2852988 | PLAN +10,50 | 3600.001 Tilluft
2852989 | PLAN +10,50 | 3600.001 Tilluft
2852990 | PLAN +10,50 | 3600.001 Tilluft
2852991 | PLAN +10,50 | 3600.001 Tilluft

# IfcDistributionPort (1484)
Description: Flow
Name | FlowDirection | Group
Port_1668463_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 17
Port_2203930_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303476_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2203930_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801292_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
InPort_2204147_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204800_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
Port_2262210_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262220_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262210_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2843100_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262220_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262676_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262546_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262684_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262546_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262976_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262676_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801329_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262684_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801326_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262866_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2578319_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262866_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2262976_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2265007_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2848433_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2265007_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266118_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266107_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802194_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266107_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802224_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266118_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802191_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266343_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266573_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266343_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762539_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266345_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801623_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266345_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2577762_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2266573_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801620_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2271470_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2274832_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2271470_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2271470_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2818831_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2274780_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2801381_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2274780_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2274832_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2275638_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2275793_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2275638_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2530912_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2275638_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276731_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2275793_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2818797_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2275810_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2530910_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2275810_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2530912_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
InPort_2275810_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2421559_1 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2275810_4 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2680234_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276717_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276731_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276717_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276795_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276785_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276795_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276785_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276809_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2276809_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2325504_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2277505_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2680237_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2277505_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2587786_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2278088_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2577503_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278088_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2587795_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278123_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2577503_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278123_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278781_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278771_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278781_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2278771_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2370621_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2279424_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2484854_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279424_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279448_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279440_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279646_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279440_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279798_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279440_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2849602_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279448_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279620_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279620_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279646_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279718_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279734_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279718_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279744_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279734_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279798_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279738_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2812566_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279738_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2858839_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2279744_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2812563_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2298738_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303059_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2298738_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303098_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303056_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303059_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303056_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303063_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303063_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2326999_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303090_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303098_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303090_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303181_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303175_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303181_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303175_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303211_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303203_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303211_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303203_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303422_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2577812_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2303422_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2303490_3 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2303446_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2577415_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2303446_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2303499_3 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2303473_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303476_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303473_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303508_3 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2303490_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762515_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2511805_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2303490_2 | SOURCE | 3600.001.04 Tilluft: 8
Port_2303499_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2484904_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
InPort_2303499_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2485170_1 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2303508_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2484823_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
InPort_2303508_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2419719_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2417068_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2303775_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2303775_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2511900_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493899_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2303775_6 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493901_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2303775_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493903_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2303775_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493905_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2303775_9 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419719_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2303853_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2303853_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2419590_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
OutPort_2303997_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2304107_0 | SINK | 3600.001.04 Tilluft: 8
Port_2315746_0 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2315813_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2315746_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2315765_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2315765_2 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2315813_2 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2496832_0 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2325504_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2326999_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2858839_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
InPort_2326999_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2767811_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334226_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2334951_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2840379_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2334226_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2840381_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2334241_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334241_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2335032_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513046_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2334819_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334819_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2370529_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334819_5 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513040_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334819_6 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513044_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334951_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368547_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513237_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2334968_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334968_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391364_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334968_5 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513219_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2334968_6 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2770149_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2335032_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513198_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2335207_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2335618_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2369790_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2335207_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2335618_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2335615_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2335615_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2335622_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2335622_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2367311_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2336964_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2337493_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2398247_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2336964_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2511167_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2336964_6 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2511174_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2336964_8 | SOURCE | 3600.001.04 Tilluft: 8
Port_2336964_9 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2511176_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2851799_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2336964_10 | SOURCE | 3600.001.04 Tilluft: 8
Port_2337482_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2337493_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2337482_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2337828_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2337551_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 22
Port_2337551_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 22
Port_2337828_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2338194_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2338194_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2339354_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2342464_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2339824_1 | SINK | 3600.001.01 Inntak: 13
OutPort_2339354_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2339810_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2339824_2 | SOURCE | 3600.001.01 Inntak: 13
InPort_2341020_2 | SINK | 3600.001.01 Inntak: 13
OutPort_2339810_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2340688_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2341020_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2341907_1 | SINK | 3600.001.01 Inntak: 13
OutPort_2340688_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2341409_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2341983_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2342378_1 | SINK | 3600.001.01 Inntak: 13
OutPort_2341409_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2341899_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2420298_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2341983_2 | SINK | 3600.001.01 Inntak: 13
OutPort_2341899_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2420317_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2341907_2 | SOURCE | 3600.001.01 Inntak: 13
InPort_2342455_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2433396_1 | SOURCE | 3600.001.01 Inntak: 13
OutPort_2342455_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2342464_2 | SINK | 3600.001.01 Inntak: 13
OutPort_2850054_0 | SOURCE | 3600.001.01 Inntak: 13
Port_2342572_0 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2770322_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2342572_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344376_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2342890_0 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344994_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2342890_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344374_2 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344371_0 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344374_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344371_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344376_2 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344421_0 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2344833_2 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2344421_1 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2345922_1 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2344830_0 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2770322_2 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344830_1 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2344833_1 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2344985_0 | SOURCEANDSINK | 3600.001.01 Inntak: 25
Port_2344985_1 | SOURCEANDSINK | 3600.001.01 Inntak: 25
Port_2344994_2 | SOURCEANDSINK | 3600.001.01 Inntak: 27
Port_2345535_0 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2420439_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2345535_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2345601_2 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2345599_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2420437_0 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2345599_2 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2345601_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2496832_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2345909_0 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2345922_2 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2345909_1 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2770247_1 | SOURCEANDSINK | 3600.001.01 Inntak: 26
InPort_2346320_0 | SINK | 3600.001.01 Inntak: 7
OutPort_2850103_1 | SOURCE | 3600.001.01 Inntak: 7
InPort_2346711_2 | SINK | 3600.001.01 Inntak: 7
OutPort_2346320_1 | SOURCE | 3600.001.01 Inntak: 7
Port_2346414_0 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2770247_2 | SOURCEANDSINK | 3600.001.01 Inntak: 26
Port_2346414_1 | SOURCEANDSINK | 3600.001.01 Inntak: 26
InPort_2346509_1 | SINK | 3600.001.01 Inntak: 7
OutPort_2346503_0 | SOURCE | 3600.001.01 Inntak: 7
InPort_2346503_1 | SINK | 3600.001.01 Inntak: 7
OutPort_2346711_1 | SOURCE | 3600.001.01 Inntak: 7
OutPort_2346509_2 | SOURCE | 3600.001.01 Inntak: 7
InPort_2346769_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416615_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347354_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2346769_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2409271_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2346769_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2346902_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2409263_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416490_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2346902_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347024_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2409267_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416498_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347024_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347035_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416506_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347330_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347035_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347187_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347197_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2491712_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347187_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347197_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416487_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347297_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347300_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2491714_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347297_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347300_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416495_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2347327_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347330_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2491715_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2347327_1 | SOURCE | 3600.001.04 Tilluft: 8
Port_2348961_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2348961_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350604_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2349036_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350634_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2349036_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2349302_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350756_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2349302_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2349940_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2349861_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2349940_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2349861_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350139_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350031_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350137_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350031_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2370760_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350134_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350137_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350134_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350139_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350201_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350871_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350201_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2351199_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350260_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350837_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350260_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350871_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350588_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350604_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350588_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350756_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2350624_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350634_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350624_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350832_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350829_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350832_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350829_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350837_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350919_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2351199_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2350919_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2370816_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
InPort_2351480_0 | SINK | 3600.001.01 Inntak: 8
OutPort_2352246_2 | SOURCE | 3600.001.01 Inntak: 8
OutPort_2351480_1 | SOURCE | 3600.001.01 Inntak: 8
Port_2351724_0 | SOURCEANDSINK | 3600.001.02 Avkast: 2
Port_2351724_1 | SOURCEANDSINK | 3600.001.02 Avkast: 2
Port_2352014_2 | SOURCEANDSINK | 3600.001.02 Avkast: 2
Port_2352006_0 | SOURCEANDSINK | 3600.001.02 Avkast: 2
Port_2352014_1 | SOURCEANDSINK | 3600.001.02 Avkast: 2
Port_2352006_1 | SOURCEANDSINK | 3600.001.02 Avkast: 2
InPort_2352246_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2352238_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2352238_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2352311_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2352311_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2352303_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2352303_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2352321_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2352321_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2352315_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2352315_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2353119_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353119_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353109_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353109_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2353131_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353131_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353123_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353123_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2353413_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353413_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353405_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353405_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2353520_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353520_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353512_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353512_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2420554_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2420550_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353596_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353596_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2353666_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353666_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353660_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353660_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2353678_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353678_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2353670_0 | SOURCE | 3600.001.01 Inntak: 8
InPort_2353670_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2359282_2 | SOURCE | 3600.001.01 Inntak: 8
InPort_2354494_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2353944_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2353944_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762619_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354486_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416362_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2852048_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354486_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416359_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354494_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354550_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354558_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354618_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354550_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354558_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2852045_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354612_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354618_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2355169_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354612_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2388798_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354612_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2388802_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354612_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354709_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2388798_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2355085_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354709_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2354956_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2388802_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2355117_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2354956_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2355082_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2355085_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2359633_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2355082_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2355114_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2355117_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2359619_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2355114_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2355298_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2388761_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2359665_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2355298_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2356526_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2388759_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2359661_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2356526_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2357366_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2358388_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2425714_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2357366_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2358388_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2357729_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2357729_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2357976_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2357976_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2358121_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2358121_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2511167_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2358660_0 | SINK | 3600.001.01 Inntak: 8
OutPort_2447087_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2359115_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2358660_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2359100_0 | SINK | 3600.001.01 Inntak: 8
OutPort_2359115_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2359282_1 | SINK | 3600.001.01 Inntak: 8
OutPort_2359100_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2416663_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2359619_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2388704_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2359633_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2367311_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369461_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368159_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368163_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2369800_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368159_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368163_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368161_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368161_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368165_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368165_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368171_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368171_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369463_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2369780_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368454_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368454_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391762_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368496_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391766_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391778_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368496_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368547_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2368550_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368550_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513046_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2368550_3 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2370309_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2369777_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369780_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2370529_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369777_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2770080_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369790_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2369797_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369800_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513219_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2369797_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2370309_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513114_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513114_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2370449_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2370449_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2370457_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2370457_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391775_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2370618_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2818831_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2370618_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2370621_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2370760_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2511184_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2370816_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2511190_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
InPort_2767560_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2371009_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2371009_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2840383_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373397_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373401_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373448_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373397_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373401_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373399_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373399_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373403_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373403_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373409_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373409_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373439_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373425_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373429_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373454_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373425_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373429_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373427_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373427_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373431_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373431_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373437_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373437_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373441_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2459235_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373448_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2373452_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373454_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513044_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2373452_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2416658_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2388704_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2388711_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416666_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2388761_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2388711_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2388759_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416655_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2840376_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2388990_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2769848_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2390876_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2390876_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391320_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2390965_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391774_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391324_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2390965_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391771_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391243_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391320_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391317_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391317_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391324_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391782_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391361_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391361_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391765_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391364_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391779_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391774_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391771_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391775_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391778_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2391779_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2391782_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2762281_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2397819_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2397819_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2511174_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2398378_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2425711_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2409263_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416595_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2409267_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416607_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416503_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2409271_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416374_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416359_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416362_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416371_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416371_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416374_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416487_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416490_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416495_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416498_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416506_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416503_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416589_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2851802_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2851567_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416589_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416591_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2851564_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416595_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416591_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416597_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416595_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416601_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416597_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416603_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416601_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416607_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416603_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416609_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416607_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416613_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416609_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416615_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416613_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416655_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416658_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2416666_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2416663_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417092_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493899_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417327_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417092_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417308_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417612_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417361_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417308_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417610_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417327_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417353_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417361_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2598275_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417353_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417612_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417610_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417794_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417700_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417700_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419306_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417709_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417719_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417758_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417709_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417719_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417791_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2417791_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2417794_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418174_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418165_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418165_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419254_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418167_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418169_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418171_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418167_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418169_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418172_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418172_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418174_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418194_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418185_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418185_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419150_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418187_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418189_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418191_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418187_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418189_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418192_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418192_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418194_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418512_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418503_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418503_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419202_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418505_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418507_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418509_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418505_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418507_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418510_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418510_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418512_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418545_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418536_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418536_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419099_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418538_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418540_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418542_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418538_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418540_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418543_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2418543_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2418545_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419096_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762534_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419099_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419096_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419147_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848429_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419150_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419147_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419199_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848425_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419202_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419199_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419251_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848421_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419254_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419251_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419303_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848437_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419306_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2419303_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2419590_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2419578_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2419578_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2419601_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2419601_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2419593_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2419593_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513280_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2420296_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2420319_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2420298_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2420296_1 | SOURCE | 3600.001.01 Inntak: 13
InPort_2420319_0 | SINK | 3600.001.01 Inntak: 13
OutPort_2420317_1 | SOURCE | 3600.001.01 Inntak: 13
Port_2420437_1 | SOURCEANDSINK | 3600.001.01 Inntak: 17
Port_2420439_0 | SOURCEANDSINK | 3600.001.01 Inntak: 17
InPort_2420547_0 | SINK | 3600.001.01 Inntak: 8
OutPort_2420550_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2420554_2 | SINK | 3600.001.01 Inntak: 8
OutPort_2420547_1 | SOURCE | 3600.001.01 Inntak: 8
InPort_2598154_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2420808_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2420808_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2420859_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2420859_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2421083_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422263_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2420964_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2420964_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422197_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2421912_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_6 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422263_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_7 | SINK | 3600.001.05 Avtrekk: 7
