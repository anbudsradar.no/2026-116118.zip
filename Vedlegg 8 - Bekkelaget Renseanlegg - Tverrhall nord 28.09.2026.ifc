Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcDistributionPort (1484)
Name | FlowDirection | Group
OutPort_2422424_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_8 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422461_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_9 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422486_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_10 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422511_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_11 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422536_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_12 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422563_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_13 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422588_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_14 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422613_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_15 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422640_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_16 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422665_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_17 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422692_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_18 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422717_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_19 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422742_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_20 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422767_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421083_21 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422792_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421559_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2421552_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421552_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2421555_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2421555_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2598151_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422197_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422185_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422185_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422208_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422269_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422202_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422202_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422282_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422208_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422266_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422266_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422269_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422424_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422414_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422414_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422418_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422418_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422416_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422416_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422422_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422428_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422420_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422420_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422429_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422422_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422426_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422426_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422428_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422461_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422451_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422451_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422455_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422455_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422453_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422453_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422459_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422465_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422457_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422457_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422466_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422459_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422463_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422463_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422465_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422486_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422476_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422476_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422480_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422480_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422478_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422478_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422484_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422490_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422482_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422482_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422491_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422484_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422488_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422488_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422490_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422511_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422501_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422501_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422505_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422505_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422503_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422503_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422509_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422515_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422507_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422507_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422516_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422509_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422513_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422513_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422515_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422536_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422526_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422526_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422530_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422530_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422528_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422528_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422534_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422540_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422532_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422532_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422541_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422534_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422538_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422538_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422540_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422563_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422553_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422553_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422557_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422557_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422555_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422555_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422561_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422567_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422559_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422559_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422568_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422561_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422565_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422565_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422567_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422588_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422578_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422578_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422582_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422582_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422580_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422580_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422586_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422592_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422584_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422584_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422593_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422586_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422590_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422590_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422592_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422613_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422603_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422603_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422607_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422607_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422605_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422605_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422611_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422617_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422609_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422609_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422618_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422611_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422615_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422615_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422617_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422640_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422630_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422630_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422634_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422634_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422632_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422632_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422638_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422644_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422636_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422636_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422645_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422638_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422642_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422642_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422644_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422665_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422655_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422655_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422659_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422659_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422657_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422657_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422663_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422669_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422661_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422661_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422670_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422663_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422667_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422667_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422669_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422692_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422682_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422682_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422686_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422686_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422684_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422684_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422690_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422696_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422688_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422688_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422697_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422690_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422694_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422694_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422696_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422717_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422707_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422707_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422711_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422711_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422709_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422709_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422715_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422721_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422713_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422713_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422722_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422715_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422719_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422719_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422721_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422742_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422732_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422732_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422736_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422736_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422734_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422734_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422740_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422746_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422738_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422738_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422747_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422740_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422744_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422744_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422746_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422767_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422757_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422757_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422761_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422761_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422759_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422759_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422765_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422771_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422763_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422763_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422772_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422765_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422769_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422769_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422771_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422792_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422782_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422782_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422786_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422786_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422784_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422784_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422790_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422796_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422788_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422788_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422797_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422790_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422794_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2422794_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2422796_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2425711_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2425714_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426111_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426102_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426102_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427406_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426104_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426106_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426108_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426104_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426106_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426109_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426109_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426111_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426131_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426122_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426122_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427455_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426124_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426126_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426128_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426124_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426126_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426129_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426129_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426131_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426151_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426142_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426142_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427498_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426144_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426146_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426148_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426144_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426146_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426149_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426149_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426151_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426171_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426162_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426162_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427584_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426164_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426166_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426168_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426164_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426166_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426169_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426169_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426171_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426191_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426182_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426182_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427627_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426184_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426186_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426188_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426184_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426186_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426189_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426189_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426191_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426211_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426202_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426202_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427670_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426204_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426206_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426208_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426204_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426206_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426209_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426209_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426211_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426231_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426222_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426222_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427713_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426224_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426226_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426228_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426224_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426226_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426229_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2426229_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2426231_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427403_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493901_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427406_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427403_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427452_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493903_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427455_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427452_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427495_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493905_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427498_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427495_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427581_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762537_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427584_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427581_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427624_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762541_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427627_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427624_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427667_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762543_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427670_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427667_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427710_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762545_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2427713_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2427710_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2850099_1 | SINK | 3600.001.01 Inntak: 7
OutPort_2439826_1 | SOURCE | 3600.001.01 Inntak: 7
InPort_2454052_0 | SINK | 3600.001.04 Tilluft: 8
InPort_2513040_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2459235_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2471690_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471783_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471690_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801311_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471773_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471783_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471773_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471863_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2471863_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2484823_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2484823_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2484854_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2484904_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2530910_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2496987_0 | SOURCEANDSINK | 3600.001.01 Inntak: 24
Port_2496987_1 | SOURCEANDSINK | 3600.001.01 Inntak: 24
Port_2511176_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2712251_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2511184_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 3
Port_2511190_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 16
Port_2511199_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2511201_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2511199_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2802390_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2511201_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2801378_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
InPort_2511900_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2511805_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2513198_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513237_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513198_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2769848_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2767590_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2513348_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2513348_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2834137_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2575768_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2587813_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2575768_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2577415_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2577762_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801298_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2577812_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2599897_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2578072_0 | SINK | 3600.001.04 Tilluft: 8
Port_2578244_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2802390_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2578244_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2578319_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2599272_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
OutPort_2587783_0 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2587786_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2599716_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
OutPort_2587792_0 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2587795_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2599478_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
OutPort_2587801_0 | SOURCE | 3600.001.05 Avtrekk: 7
OutPort_2587810_0 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2587813_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2600033_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
InPort_2598151_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2598154_1 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2599272_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2599441_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802224_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2599441_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2599478_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2599716_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2599897_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2790198_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2600033_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2680134_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2680234_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2680134_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2680237_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2712251_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2847444_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2742126_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2742126_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762565_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2748731_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762519_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2748731_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2833495_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762281_2 | SOURCE | 3600.001.04 Tilluft: 8
Port_2762515_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762519_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2762537_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762515_8 | SOURCE | 3600.001.04 Tilluft: 8
Port_2762515_9 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762539_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2762541_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762515_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2762543_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762515_11 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2762545_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762515_12 | SOURCE | 3600.001.04 Tilluft: 8
Port_2762517_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762517_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762522_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2762534_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762519_3 | SOURCE | 3600.001.04 Tilluft: 8
Port_2762519_4 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762522_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2762565_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2848417_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2762616_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2851799_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2851802_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762616_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2762619_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2762616_2 | SOURCE | 3600.001.04 Tilluft: 8
Port_2762909_1 | SOURCEANDSINK
Port_2762909_2 | SOURCEANDSINK
Port_2762909_3 | SOURCEANDSINK
Port_2763469_1 | SOURCEANDSINK
Port_2763469_2 | SOURCEANDSINK
Port_2763469_3 | SOURCEANDSINK
Port_2763678_1 | SOURCEANDSINK
Port_2763678_2 | SOURCEANDSINK
Port_2763678_3 | SOURCEANDSINK
InPort_2767596_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2767560_2 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2767560_3 | SOURCEANDSINK
InPort_2834137_0 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2767569_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2767569_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2834159_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2767811_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2767590_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2834332_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2767596_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2770149_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2770080_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2790195_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2790198_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2790195_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801289_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801292_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801289_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801298_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801308_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801311_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801308_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2801326_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801329_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801378_0 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2801381_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 10
Port_2801620_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2801623_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802191_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802194_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2802844_1 | SOURCEANDSINK
Port_2802844_2 | SOURCEANDSINK
Port_2802844_3 | SOURCEANDSINK
InPort_2805089_1 | SINK
Port_2812563_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2812566_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2818797_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 7
Port_2818833_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 11
Port_2818833_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 11
Port_2818833_3 | SOURCEANDSINK
Port_2820258_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2849602_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2820258_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 25
Port_2826468_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 9
Port_2826468_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 9
Port_2826470_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 29
Port_2826470_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 29
Port_2826470_3 | SOURCEANDSINK
Port_2826822_0 | SOURCEANDSINK | 3600.001.02 Avkast: 1
Port_2826822_1 | SOURCEANDSINK | 3600.001.02 Avkast: 1
Port_2832977_0 | SOURCEANDSINK | 3600.001.02 Avkast: 7
Port_2832977_1 | SOURCEANDSINK | 3600.001.02 Avkast: 7
InPort_2848203_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2833495_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2848197_1 | SINK | 3600.001.04 Tilluft: 11
OutPort_2833521_0 | SOURCE | 3600.001.04 Tilluft: 11
InPort_2833521_1 | SINK | 3600.001.04 Tilluft: 11
InPort_2834159_1 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2834332_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2840383_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2840376_0 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2840376_2 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2840379_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
InPort_2840376_3 | SINK | 3600.001.08 Spesialavtrekk: 25
OutPort_2840381_1 | SOURCE | 3600.001.08 Spesialavtrekk: 25
Port_2840383_3 | SOURCEANDSINK
Port_2843052_0 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2847444_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2843052_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2843100_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2847783_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 5
Port_2847783_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 5
Port_2847783_3 | SOURCEANDSINK
Port_2847884_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 10
Port_2847884_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 10
Port_2847884_3 | SOURCEANDSINK
Port_2848328_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 12
Port_2848328_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 12
Port_2848328_3 | SOURCEANDSINK
Port_2848329_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 15
Port_2848329_2 | SOURCEANDSINK | 3600.001.04 Tilluft: 15
Port_2848329_3 | SOURCEANDSINK
Port_2848417_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2848421_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848417_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2848425_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848417_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2848429_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848417_9 | SOURCE | 3600.001.04 Tilluft: 8
Port_2848417_10 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
Port_2848433_1 | SOURCEANDSINK | 3600.001.04 Tilluft: 8
InPort_2848437_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2848417_11 | SOURCE | 3600.001.04 Tilluft: 8
Port_2848730_1 | SOURCEANDSINK | 3600.001.02 Avkast: 6
Port_2848730_2 | SOURCEANDSINK | 3600.001.02 Avkast: 6
Port_2848730_3 | SOURCEANDSINK
Port_2848774_1 | SOURCEANDSINK | 3600.001.02 Avkast: 3
Port_2848774_2 | SOURCEANDSINK | 3600.001.02 Avkast: 3
Port_2848774_3 | SOURCEANDSINK
Port_2849293_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 30
Port_2849293_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 30
Port_2849293_3 | SOURCEANDSINK
Port_2849776_1 | SOURCEANDSINK | 3600.001.05 Avtrekk: 12
Port_2849776_2 | SOURCEANDSINK | 3600.001.05 Avtrekk: 12
Port_2849776_3 | SOURCEANDSINK
Port_2850052_1 | SOURCEANDSINK | 3600.001.01 Inntak: 28
Port_2850052_2 | SOURCEANDSINK | 3600.001.01 Inntak: 28
Port_2850052_3 | SOURCEANDSINK
InPort_2850054_1 | SINK | 3600.001.01 Inntak: 13
InPort_2850103_2 | SINK | 3600.001.01 Inntak: 7
OutPort_2850099_0 | SOURCE | 3600.001.01 Inntak: 7
Port_2850167_1 | SOURCEANDSINK | 3600.001.01 Inntak: 29
Port_2850167_2 | SOURCEANDSINK | 3600.001.01 Inntak: 29
Port_2850167_3 | SOURCEANDSINK
InPort_2851564_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2851567_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2852045_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2852048_1 | SOURCE | 3600.001.04 Tilluft: 8
Port_2852048_3 | SOURCEANDSINK

# IfcFlowFitting: Lindab ESU:ESU (8)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: ESU; sets with these values: 2
Name (Lindab ESU:ESU:...) | Group
2342378 | 3600.001.01 Inntak: 13
2347354 | 3600.001.04 Tilluft: 8
2355169 | 3600.001.04 Tilluft: 8
2417068 | 3600.001.04 Tilluft: 8
2421912 | 3600.001.05 Avtrekk: 7
2598275 | 3600.001.04 Tilluft: 8
2848197 | 3600.001.04 Tilluft: 11
2848203 | 3600.001.04 Tilluft: 8

# IfcFlowFitting: Lindab LBR:LBR (2)
In: 0-Havnivå
Type - Description: Bend, Rektangulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: LBR; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (Lindab LBR:LBR:...)
2337493
2337828

# IfcFlowFitting: Lindab LEPR:LEPR, Lindab LEPR:LEPR:2398247
In: 0-Havnivå
Type - Description: Endelokk, Rektangulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: LEPR; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcFlowFitting: Lindab NPU:NPU (9)
In: 0-Havnivå
Type - Description: Skjøt, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: NPU; sets with these values: 2
Name (Lindab NPU:NPU:...) | Group
2416591 | 3600.001.04 Tilluft: 8
2416597 | 3600.001.04 Tilluft: 8
2416603 | 3600.001.04 Tilluft: 8
2416609 | 3600.001.04 Tilluft: 8
2416615 | 3600.001.04 Tilluft: 8
2417612 | 3600.001.04 Tilluft: 8
2420298 | 3600.001.01 Inntak: 13
2420319 | 3600.001.01 Inntak: 13
2420439 | 3600.001.01 Inntak: 17

# IfcFlowFitting: Lindab XCPU:XCPU, Lindab XCPU:XCPU:2762519
In: 0-Havnivå
Type - Description: X-stykke, Sirkulær; Material: DF_Material1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lindab
Pset_DistributionFlowElementCommon - Reference: XCPU; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (39)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2276795 | 3600.001.05 Avtrekk: 7
2276809 | 3600.001.05 Avtrekk: 7
2350832 | 3600.001.05 Avtrekk: 16
2350837 | 3600.001.05 Avtrekk: 16
2351199 | 3600.001.05 Avtrekk: 16
2420859 | 3600.001.05 Avtrekk: 7
2421555 | 3600.001.05 Avtrekk: 7
2422197 | 3600.001.05 Avtrekk: 7
2422208 | 3600.001.05 Avtrekk: 7
2422418 | 3600.001.05 Avtrekk: 7
2422422 | 3600.001.05 Avtrekk: 7
2422455 | 3600.001.05 Avtrekk: 7
2422459 | 3600.001.05 Avtrekk: 7
2422480 | 3600.001.05 Avtrekk: 7
2422484 | 3600.001.05 Avtrekk: 7
2422505 | 3600.001.05 Avtrekk: 7
2422509 | 3600.001.05 Avtrekk: 7
2422530 | 3600.001.05 Avtrekk: 7
2422534 | 3600.001.05 Avtrekk: 7
2422557 | 3600.001.05 Avtrekk: 7
2422561 | 3600.001.05 Avtrekk: 7
2422582 | 3600.001.05 Avtrekk: 7
2422586 | 3600.001.05 Avtrekk: 7
2422607 | 3600.001.05 Avtrekk: 7
2422611 | 3600.001.05 Avtrekk: 7
2422634 | 3600.001.05 Avtrekk: 7
2422638 | 3600.001.05 Avtrekk: 7
2422659 | 3600.001.05 Avtrekk: 7
2422663 | 3600.001.05 Avtrekk: 7
2422686 | 3600.001.05 Avtrekk: 7
2422690 | 3600.001.05 Avtrekk: 7
2422711 | 3600.001.05 Avtrekk: 7
2422715 | 3600.001.05 Avtrekk: 7
2422736 | 3600.001.05 Avtrekk: 7
2422740 | 3600.001.05 Avtrekk: 7
2422761 | 3600.001.05 Avtrekk: 7
2422765 | 3600.001.05 Avtrekk: 7
2422786 | 3600.001.05 Avtrekk: 7
2422790 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (16)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Inntak
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2339824 | 3600.001.01 Inntak: 13
2341020 | 3600.001.01 Inntak: 13
2341907 | 3600.001.01 Inntak: 13
2341983 | 3600.001.01 Inntak: 13
2342464 | 3600.001.01 Inntak: 13
2344374 | 3600.001.01 Inntak: 27
2344376 | 3600.001.01 Inntak: 27
2344833 | 3600.001.01 Inntak: 26
2344994 | 3600.001.01 Inntak: 27
2345601 | 3600.001.01 Inntak: 17
2345922 | 3600.001.01 Inntak: 26
2346509 | 3600.001.01 Inntak: 7
2346711 | 3600.001.01 Inntak: 7
2359115 | 3600.001.01 Inntak: 8
2359282 | 3600.001.01 Inntak: 8
2770322 | 3600.001.01 Inntak: 27

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (31)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2303059 | 3600.001.08 Spesialavtrekk: 25
2303063 | 3600.001.08 Spesialavtrekk: 25
2303098 | 3600.001.08 Spesialavtrekk: 25
2303181 | 3600.001.08 Spesialavtrekk: 25
2303211 | 3600.001.08 Spesialavtrekk: 25
2303476 | 3600.001.08 Spesialavtrekk: 25
2334951 | 3600.001.08 Spesialavtrekk: 25
2335032 | 3600.001.08 Spesialavtrekk: 25
2335618 | 3600.001.08 Spesialavtrekk: 25
2335622 | 3600.001.08 Spesialavtrekk: 25
2355085 | 3600.001.04 Tilluft: 8
2355117 | 3600.001.04 Tilluft: 8
2358388 | 3600.001.04 Tilluft: 8
2359619 | 3600.001.04 Tilluft: 8
2359633 | 3600.001.04 Tilluft: 8
2368163 | 3600.001.08 Spesialavtrekk: 25
2368165 | 3600.001.08 Spesialavtrekk: 25
2370457 | 3600.001.08 Spesialavtrekk: 25
2370529 | 3600.001.08 Spesialavtrekk: 25
2373401 | 3600.001.08 Spesialavtrekk: 25
2373403 | 3600.001.08 Spesialavtrekk: 25
2373429 | 3600.001.08 Spesialavtrekk: 25
2373431 | 3600.001.08 Spesialavtrekk: 25
2391320 | 3600.001.08 Spesialavtrekk: 25
2391324 | 3600.001.08 Spesialavtrekk: 25
2391364 | 3600.001.08 Spesialavtrekk: 25
2419590 | 3600.001.08 Spesialavtrekk: 25
2419601 | 3600.001.08 Spesialavtrekk: 25
2471783 | 3600.001.08 Spesialavtrekk: 25
2513114 | 3600.001.08 Spesialavtrekk: 25
2851802 | 3600.001.04 Tilluft: 8

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (82)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2262220 | 3600.001.04 Tilluft: 8
2262684 | 3600.001.04 Tilluft: 8
2262976 | 3600.001.04 Tilluft: 8
2266118 | 3600.001.04 Tilluft: 8
2266573 | 3600.001.04 Tilluft: 8
2278781 | 3600.001.05 Avtrekk: 10
2279448 | 3600.001.08 Spesialavtrekk: 25
2279734 | 3600.001.08 Spesialavtrekk: 25
2279744 | 3600.001.08 Spesialavtrekk: 25
2315765 | 3600.001.01 Inntak: 17
2315813 | 3600.001.01 Inntak: 17
2345599 | 3600.001.01 Inntak: 17
2347197 | 3600.001.04 Tilluft: 8
2347300 | 3600.001.04 Tilluft: 8
2347330 | 3600.001.04 Tilluft: 8
2349940 | 3600.001.04 Tilluft: 3
2350137 | 3600.001.04 Tilluft: 3
2350139 | 3600.001.04 Tilluft: 3
2350604 | 3600.001.04 Tilluft: 3
2350634 | 3600.001.05 Avtrekk: 16
2350756 | 3600.001.04 Tilluft: 3
2350871 | 3600.001.05 Avtrekk: 16
2352014 | 3600.001.02 Avkast: 2
2352246 | 3600.001.01 Inntak: 8
2352311 | 3600.001.01 Inntak: 8
2352321 | 3600.001.01 Inntak: 8
2353119 | 3600.001.01 Inntak: 8
2353131 | 3600.001.01 Inntak: 8
2353413 | 3600.001.01 Inntak: 8
2353520 | 3600.001.01 Inntak: 8
2353666 | 3600.001.01 Inntak: 8
2353678 | 3600.001.01 Inntak: 8
2354494 | 3600.001.04 Tilluft: 8
2354558 | 3600.001.04 Tilluft: 8
2354618 | 3600.001.04 Tilluft: 8
2357976 | 3600.001.04 Tilluft: 8
2370621 | 3600.001.05 Avtrekk: 10
2370760 | 3600.001.04 Tilluft: 3
2370816 | 3600.001.05 Avtrekk: 16
2417327 | 3600.001.04 Tilluft: 8
2417361 | 3600.001.04 Tilluft: 8
2417719 | 3600.001.04 Tilluft: 8
2418169 | 3600.001.04 Tilluft: 8
2418189 | 3600.001.04 Tilluft: 8
2418507 | 3600.001.04 Tilluft: 8
2418540 | 3600.001.04 Tilluft: 8
2419099 | 3600.001.04 Tilluft: 8
2419150 | 3600.001.04 Tilluft: 8
2419202 | 3600.001.04 Tilluft: 8
2419254 | 3600.001.04 Tilluft: 8
2419306 | 3600.001.04 Tilluft: 8
2420550 | 3600.001.01 Inntak: 8
2420554 | 3600.001.01 Inntak: 8
2426106 | 3600.001.04 Tilluft: 8
2426126 | 3600.001.04 Tilluft: 8
2426146 | 3600.001.04 Tilluft: 8
2426166 | 3600.001.04 Tilluft: 8
2426186 | 3600.001.04 Tilluft: 8
2426206 | 3600.001.04 Tilluft: 8
2426226 | 3600.001.04 Tilluft: 8
2427406 | 3600.001.04 Tilluft: 8
2427455 | 3600.001.04 Tilluft: 8
2427498 | 3600.001.04 Tilluft: 8
2427584 | 3600.001.04 Tilluft: 8
2427627 | 3600.001.04 Tilluft: 8
2427670 | 3600.001.04 Tilluft: 8
2427713 | 3600.001.04 Tilluft: 8
2484854 | 3600.001.08 Spesialavtrekk: 25
2511201 | 3600.001.05 Avtrekk: 10
2577415 | 3600.001.05 Avtrekk: 7
2577503 | 3600.001.05 Avtrekk: 10
2577762 | 3600.001.04 Tilluft: 8
2577812 | 3600.001.04 Tilluft: 8
2578319 | 3600.001.04 Tilluft: 8
2680237 | 3600.001.05 Avtrekk: 7
2762281 | 3600.001.04 Tilluft: 8
2762565 | 3600.001.04 Tilluft: 8
2770247 | 3600.001.01 Inntak: 26
2802224 | 3600.001.04 Tilluft: 8
2802390 | 3600.001.05 Avtrekk: 10
2834332 | 3600.001.08 Spesialavtrekk: 25
2843100 | 3600.001.04 Tilluft: 8

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001, magicirc_plug_001:magicirc_plug_001:2485170
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001 (2)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (magicirc_plug_001:magicirc_plug_001:...)
2388990
2513280

# IfcFlowFitting: magicirc_reduction_001:magicirc_reduction_001 (14)
In: 0-Havnivå
Type - Description: Overgang, Sirkulær; Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_001; sets with these values: 2
Name (magicirc_reduction_001:magicirc_reduction_001:...) | Group
2274832 | 3600.001.05 Avtrekk: 10
2279646 | 3600.001.08 Spesialavtrekk: 25
2279798 | 3600.001.08 Spesialavtrekk: 25
2388759 | 3600.001.04 Tilluft: 8
2388761 | 3600.001.04 Tilluft: 8
2419719 | 3600.001.08 Spesialavtrekk: 25
2511900 | 3600.001.04 Tilluft: 8
2513046 | 3600.001.08 Spesialavtrekk: 25
2513237 | 3600.001.08 Spesialavtrekk: 25
2530910 | 3600.001.05 Avtrekk: 7
2530912 | 3600.001.05 Avtrekk: 7
2762522 | 3600.001.04 Tilluft: 8
2762534 | 3600.001.04 Tilluft: 8
2858839 | 3600.001.08 Spesialavtrekk: 25

# IfcFlowFitting: magicirc_reduction_001:magicirc_reduction_001 Galv, magicirc_reduction_001:magicirc_reduction_001 Galv:2275793
In: 0-Havnivå
Type - Description: Overgang, Sirkulær, Galvanisert; Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_001 Galv; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (20)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...) | Group
2276731 | 3600.001.05 Avtrekk: 7
2421559 | 3600.001.05 Avtrekk: 7
2422263 | 3600.001.05 Avtrekk: 7
2422424 | 3600.001.05 Avtrekk: 7
2422461 | 3600.001.05 Avtrekk: 7
2422486 | 3600.001.05 Avtrekk: 7
2422511 | 3600.001.05 Avtrekk: 7
2422536 | 3600.001.05 Avtrekk: 7
2422563 | 3600.001.05 Avtrekk: 7
2422588 | 3600.001.05 Avtrekk: 7
2422613 | 3600.001.05 Avtrekk: 7
2422640 | 3600.001.05 Avtrekk: 7
2422665 | 3600.001.05 Avtrekk: 7
2422692 | 3600.001.05 Avtrekk: 7
2422717 | 3600.001.05 Avtrekk: 7
2422742 | 3600.001.05 Avtrekk: 7
2422767 | 3600.001.05 Avtrekk: 7
2422792 | 3600.001.05 Avtrekk: 7
2680234 | 3600.001.05 Avtrekk: 7
2818831 | 3600.001.05 Avtrekk: 10

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (9)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2471863
2513040
2513044
2513219
2767811
2769848
2770149
2840379
2849602

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (25)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...) | Group
2388798 | 3600.001.04 Tilluft: 8
2388802 | 3600.001.04 Tilluft: 8
2409263 | 3600.001.04 Tilluft: 8
2409267 | 3600.001.04 Tilluft: 8
2409271 | 3600.001.04 Tilluft: 8
2493899 | 3600.001.04 Tilluft: 8
2493901 | 3600.001.04 Tilluft: 8
2493903 | 3600.001.04 Tilluft: 8
2493905 | 3600.001.04 Tilluft: 8
2511167 | 3600.001.04 Tilluft: 8
2511174 | 3600.001.04 Tilluft: 8
2511176 | 3600.001.04 Tilluft: 8
2762537 | 3600.001.04 Tilluft: 8
2762539 | 3600.001.04 Tilluft: 8
2762541 | 3600.001.04 Tilluft: 8
2762543 | 3600.001.04 Tilluft: 8
2762545 | 3600.001.04 Tilluft: 8
2762619 | 3600.001.04 Tilluft: 8
2840381 | 3600.001.08 Spesialavtrekk: 25
2848421 | 3600.001.04 Tilluft: 8
2848425 | 3600.001.04 Tilluft: 8
2848429 | 3600.001.04 Tilluft: 8
2848433 | 3600.001.04 Tilluft: 8
2848437 | 3600.001.04 Tilluft: 8
2851799 | 3600.001.04 Tilluft: 8

# IfcFlowFitting: magicirc_tee_centric_90_001:magicirc_tee_centric_90_001, magicirc_tee_centric_90_001:magicirc_tee_centric_90_001:2303499
In: 0-Havnivå
Type - Description: Circular/circular, sharply rounded; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tee_centric_90_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_tee_centric_90_001:magicirc_tee_centric_90_001 (2)
In: 0-Havnivå
Type - Description: Circular/circular, sharply rounded; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tee_centric_90_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 25
Name (magicirc_tee_centric_90_001:magicirc_tee_centric_90_001:...)
2303508
2368550

# IfcFlowFitting: magicirc_tee_centric_90_001:magicirc_tee_centric_90_001, magicirc_tee_centric_90_001:magicirc_tee_centric_90_001:2303490
In: 0-Havnivå
Type - Description: Circular/circular, sharply rounded; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_tee_centric_90_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcFlowSegment: Rectangular Duct:Rektangulær kanal (4)
In: 0-Havnivå
Type - Description: Rektangulær kanal, forsinket stål; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Rektangulær kanal; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Rectangular Duct:Rektangulær kanal:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2336964 | 6088.5 | 3600.001.04 Tilluft: 8
2337482 | 4539.7 | 3600.001.04 Tilluft: 8
2337551 | 9677.72 | 3600.001.04 Tilluft: 22
2338194 | 2468.5 | 3600.001.04 Tilluft: 8

# IfcFlowSegment: Round Duct:Sirkulær kanal (7)
In: 0-Havnivå
Type - Description: Sirkulær kanal, Syrefast stål; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1668463 | 7071.69 | 3600.001.08 Spesialavtrekk: 17
2820258 | 11260 | 3600.001.08 Spesialavtrekk: 25
2826468 | 6637.18 | 3600.001.08 Spesialavtrekk: 9
2826822 | 4108.02 | 3600.001.02 Avkast: 1
2832977 | 7491.98 | 3600.001.02 Avkast: 7
2833495 | 1430.47 | 3600.001.04 Tilluft: 8
2833521 | 1365.16 | 3600.001.04 Tilluft: 11

# IfcFlowSegment: Round Duct:Sirkulær kanal Galv (254)
In: 0-Havnivå
Type - Description: Sirkulær kanal, Galvanisert stål; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal Galv; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal Galv:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2204147 | 794 | 3600.001.04 Tilluft: 8
2262210 | 185.596 | 3600.001.04 Tilluft: 8
2262546 | 751.944 | 3600.001.04 Tilluft: 8
2262676 | 5087.29 | 3600.001.04 Tilluft: 8
2262866 | 1847.07 | 3600.001.04 Tilluft: 8
2265007 | 571.013 | 3600.001.04 Tilluft: 8
2266107 | 1416.91 | 3600.001.04 Tilluft: 8
2266343 | 579.877 | 3600.001.04 Tilluft: 8
2266345 | 1389.07 | 3600.001.04 Tilluft: 8
2275638 | 3570.97 | 3600.001.05 Avtrekk: 7
2275810 | 18532.2 | 3600.001.05 Avtrekk: 7
2276717 | 2997.26 | 3600.001.05 Avtrekk: 7
2276785 | 1274.52 | 3600.001.05 Avtrekk: 7
2303422 | 429.111 | 3600.001.04 Tilluft: 8
2303775 | 26360 | 3600.001.04 Tilluft: 8
2304107 | 887.5 | 3600.001.04 Tilluft: 8
2315746 | 1199.53 | 3600.001.01 Inntak: 17
2325504 | 2609.38 | 3600.001.05 Avtrekk: 7
2339354 | 5951.42 | 3600.001.01 Inntak: 13
2339810 | 3344.91 | 3600.001.01 Inntak: 13
2340688 | 39.7649 | 3600.001.01 Inntak: 13
2341409 | 980 | 3600.001.01 Inntak: 13
2341899 | 3236.02 | 3600.001.01 Inntak: 13
2342455 | 1192.61 | 3600.001.01 Inntak: 13
2342572 | 1365.73 | 3600.001.01 Inntak: 27
2342890 | 2937.33 | 3600.001.01 Inntak: 27
2344371 | 268.126 | 3600.001.01 Inntak: 27
2344421 | 266.13 | 3600.001.01 Inntak: 26
2344830 | 206.944 | 3600.001.01 Inntak: 27
2344985 | 276.1 | 3600.001.01 Inntak: 25
2345535 | 604.321 | 3600.001.01 Inntak: 17
2345909 | 1976.38 | 3600.001.01 Inntak: 26
2346320 | 1678.21 | 3600.001.01 Inntak: 7
2346414 | 250 | 3600.001.01 Inntak: 26
2346503 | 1228.37 | 3600.001.01 Inntak: 7
2346769 | 1420.31 | 3600.001.04 Tilluft: 8
2346902 | 363.813 | 3600.001.04 Tilluft: 8
2347024 | 417.113 | 3600.001.04 Tilluft: 8
2347035 | 362.709 | 3600.001.04 Tilluft: 8
2347187 | 435.001 | 3600.001.04 Tilluft: 8
2347297 | 435.001 | 3600.001.04 Tilluft: 8
2347327 | 435.001 | 3600.001.04 Tilluft: 8
2348961 | 433.49 | 3600.001.04 Tilluft: 3
2349036 | 310 | 3600.001.05 Avtrekk: 16
2349302 | 5191.84 | 3600.001.04 Tilluft: 3
2349861 | 352.976 | 3600.001.04 Tilluft: 3
2350031 | 1814.57 | 3600.001.04 Tilluft: 3
2350134 | 238.776 | 3600.001.04 Tilluft: 3
2350201 | 941.778 | 3600.001.05 Avtrekk: 16
2350260 | 7068.38 | 3600.001.05 Avtrekk: 16
2350588 | 1810.7 | 3600.001.04 Tilluft: 3
2350624 | 373.529 | 3600.001.05 Avtrekk: 16
2350829 | 6.18417 | 3600.001.05 Avtrekk: 16
2350919 | 1963.62 | 3600.001.05 Avtrekk: 16
2351480 | 418.674 | 3600.001.01 Inntak: 8
2351724 | 155 | 3600.001.02 Avkast: 2
2352006 | 25 | 3600.001.02 Avkast: 2
2352238 | 10 | 3600.001.01 Inntak: 8
2352303 | 1023.44 | 3600.001.01 Inntak: 8
2352315 | 27829.5 | 3600.001.01 Inntak: 8
2353109 | 304.045 | 3600.001.01 Inntak: 8
2353123 | 2414.52 | 3600.001.01 Inntak: 8
2353405 | 1047.84 | 3600.001.01 Inntak: 8
2353512 | 8486.43 | 3600.001.01 Inntak: 8
2353596 | 4070 | 3600.001.01 Inntak: 8
2353660 | 1170 | 3600.001.01 Inntak: 8
2353670 | 1480.09 | 3600.001.01 Inntak: 8
2353944 | 1512.5 | 3600.001.04 Tilluft: 8
2354486 | 12438.5 | 3600.001.04 Tilluft: 8
2354550 | 1870 | 3600.001.04 Tilluft: 8
2354612 | 5510 | 3600.001.04 Tilluft: 8
2354709 | 1375 | 3600.001.04 Tilluft: 8
2354956 | 1375 | 3600.001.04 Tilluft: 8
2355082 | 267.552 | 3600.001.04 Tilluft: 8
2355114 | 267.822 | 3600.001.04 Tilluft: 8
2355298 | 66.4851 | 3600.001.04 Tilluft: 8
2356526 | 88.197 | 3600.001.04 Tilluft: 8
2357366 | 1912.51 | 3600.001.04 Tilluft: 8
2357729 | 6036.51 | 3600.001.04 Tilluft: 8
2358121 | 1225.89 | 3600.001.04 Tilluft: 8
2358660 | 3672.38 | 3600.001.01 Inntak: 8
2359100 | 3176.09 | 3600.001.01 Inntak: 8
2388704 | 234.478 | 3600.001.04 Tilluft: 8
2388711 | 202.574 | 3600.001.04 Tilluft: 8
2397819 | 72.4132 | 3600.001.04 Tilluft: 8
2416359 | 1013.98 | 3600.001.04 Tilluft: 8
2416371 | 428.643 | 3600.001.04 Tilluft: 8
2416487 | 348.041 | 3600.001.04 Tilluft: 8
2416495 | 294.741 | 3600.001.04 Tilluft: 8
2416503 | 349.145 | 3600.001.04 Tilluft: 8
2416589 | 1255.97 | 3600.001.04 Tilluft: 8
2416595 | 3686.5 | 3600.001.04 Tilluft: 8
2416601 | 1948.31 | 3600.001.04 Tilluft: 8
2416607 | 1459.69 | 3600.001.04 Tilluft: 8
2416613 | 2265.55 | 3600.001.04 Tilluft: 8
2416655 | 137.325 | 3600.001.04 Tilluft: 8
2416663 | 190.941 | 3600.001.04 Tilluft: 8
2417092 | 2854.09 | 3600.001.04 Tilluft: 8
2417308 | 975.179 | 3600.001.04 Tilluft: 8
2417353 | 485 | 3600.001.04 Tilluft: 8
2417610 | 6187.82 | 3600.001.04 Tilluft: 8
2417700 | 302.839 | 3600.001.04 Tilluft: 8
2417709 | 1535 | 3600.001.04 Tilluft: 8
2417791 | 243.181 | 3600.001.04 Tilluft: 8
2418165 | 382.825 | 3600.001.04 Tilluft: 8
2418167 | 1535 | 3600.001.04 Tilluft: 8
2418172 | 263.181 | 3600.001.04 Tilluft: 8
2418185 | 462.795 | 3600.001.04 Tilluft: 8
2418187 | 1535 | 3600.001.04 Tilluft: 8
2418192 | 283.181 | 3600.001.04 Tilluft: 8
2418503 | 342.811 | 3600.001.04 Tilluft: 8
2418505 | 1535 | 3600.001.04 Tilluft: 8
2418510 | 403.181 | 3600.001.04 Tilluft: 8
2418536 | 365.402 | 3600.001.04 Tilluft: 8
2418538 | 1535 | 3600.001.04 Tilluft: 8
2418543 | 716.787 | 3600.001.04 Tilluft: 8
2419096 | 222.187 | 3600.001.04 Tilluft: 8
2419147 | 313.753 | 3600.001.04 Tilluft: 8
2419199 | 313.754 | 3600.001.04 Tilluft: 8
2419251 | 313.755 | 3600.001.04 Tilluft: 8
2419303 | 313.756 | 3600.001.04 Tilluft: 8
2420296 | 5238.82 | 3600.001.01 Inntak: 13
2420317 | 888.537 | 3600.001.01 Inntak: 13
2420437 | 1713.26 | 3600.001.01 Inntak: 17
2420547 | 176.777 | 3600.001.01 Inntak: 8
2420808 | 4443.12 | 3600.001.05 Avtrekk: 7
2420964 | 331.18 | 3600.001.05 Avtrekk: 7
2421083 | 63075 | 3600.001.05 Avtrekk: 7
2421552 | 1009.35 | 3600.001.05 Avtrekk: 7
2422185 | 992.893 | 3600.001.05 Avtrekk: 7
2422202 | 2405.77 | 3600.001.05 Avtrekk: 7
2422266 | 1018.68 | 3600.001.05 Avtrekk: 7
2422414 | 331.18 | 3600.001.05 Avtrekk: 7
2422416 | 992.893 | 3600.001.05 Avtrekk: 7
2422420 | 2405.77 | 3600.001.05 Avtrekk: 7
2422426 | 1018.68 | 3600.001.05 Avtrekk: 7
2422451 | 331.18 | 3600.001.05 Avtrekk: 7
2422453 | 992.893 | 3600.001.05 Avtrekk: 7
2422457 | 2405.77 | 3600.001.05 Avtrekk: 7
2422463 | 1018.68 | 3600.001.05 Avtrekk: 7
2422476 | 331.18 | 3600.001.05 Avtrekk: 7
2422478 | 992.893 | 3600.001.05 Avtrekk: 7
2422482 | 2405.77 | 3600.001.05 Avtrekk: 7
2422488 | 1018.68 | 3600.001.05 Avtrekk: 7
2422501 | 331.18 | 3600.001.05 Avtrekk: 7
2422503 | 992.893 | 3600.001.05 Avtrekk: 7
2422507 | 2405.77 | 3600.001.05 Avtrekk: 7
2422513 | 1018.68 | 3600.001.05 Avtrekk: 7
2422526 | 331.18 | 3600.001.05 Avtrekk: 7
2422528 | 992.893 | 3600.001.05 Avtrekk: 7
2422532 | 2405.77 | 3600.001.05 Avtrekk: 7
2422538 | 1018.68 | 3600.001.05 Avtrekk: 7
2422553 | 331.18 | 3600.001.05 Avtrekk: 7
2422555 | 992.893 | 3600.001.05 Avtrekk: 7
2422559 | 2405.77 | 3600.001.05 Avtrekk: 7
2422565 | 1018.68 | 3600.001.05 Avtrekk: 7
2422578 | 331.18 | 3600.001.05 Avtrekk: 7
2422580 | 992.893 | 3600.001.05 Avtrekk: 7
2422584 | 2405.77 | 3600.001.05 Avtrekk: 7
2422590 | 1018.68 | 3600.001.05 Avtrekk: 7
2422603 | 331.18 | 3600.001.05 Avtrekk: 7
2422605 | 992.893 | 3600.001.05 Avtrekk: 7
2422609 | 2405.77 | 3600.001.05 Avtrekk: 7
2422615 | 1018.68 | 3600.001.05 Avtrekk: 7
2422630 | 331.18 | 3600.001.05 Avtrekk: 7
2422632 | 992.893 | 3600.001.05 Avtrekk: 7
2422636 | 2405.77 | 3600.001.05 Avtrekk: 7
2422642 | 1018.68 | 3600.001.05 Avtrekk: 7
2422655 | 331.18 | 3600.001.05 Avtrekk: 7
2422657 | 992.893 | 3600.001.05 Avtrekk: 7
2422661 | 2405.77 | 3600.001.05 Avtrekk: 7
2422667 | 1018.68 | 3600.001.05 Avtrekk: 7
2422682 | 331.18 | 3600.001.05 Avtrekk: 7
2422684 | 992.893 | 3600.001.05 Avtrekk: 7
2422688 | 2405.77 | 3600.001.05 Avtrekk: 7
2422694 | 1018.68 | 3600.001.05 Avtrekk: 7
2422707 | 331.18 | 3600.001.05 Avtrekk: 7
2422709 | 992.893 | 3600.001.05 Avtrekk: 7
2422713 | 2405.77 | 3600.001.05 Avtrekk: 7
2422719 | 1018.68 | 3600.001.05 Avtrekk: 7
2422732 | 331.18 | 3600.001.05 Avtrekk: 7
2422734 | 992.893 | 3600.001.05 Avtrekk: 7
2422738 | 2405.77 | 3600.001.05 Avtrekk: 7
2422744 | 1018.68 | 3600.001.05 Avtrekk: 7
2422757 | 331.18 | 3600.001.05 Avtrekk: 7
2422759 | 992.893 | 3600.001.05 Avtrekk: 7
2422763 | 2405.77 | 3600.001.05 Avtrekk: 7
2422769 | 1018.68 | 3600.001.05 Avtrekk: 7
2422782 | 331.18 | 3600.001.05 Avtrekk: 7
2422784 | 992.893 | 3600.001.05 Avtrekk: 7
2422788 | 2405.77 | 3600.001.05 Avtrekk: 7
2422794 | 1018.68 | 3600.001.05 Avtrekk: 7
2425711 | 1167.2 | 3600.001.04 Tilluft: 8
2426102 | 589.015 | 3600.001.04 Tilluft: 8
2426104 | 1535 | 3600.001.04 Tilluft: 8
2426109 | 436.864 | 3600.001.04 Tilluft: 8
2426122 | 589.015 | 3600.001.04 Tilluft: 8
2426124 | 1535 | 3600.001.04 Tilluft: 8
2426129 | 436.864 | 3600.001.04 Tilluft: 8
2426142 | 589.015 | 3600.001.04 Tilluft: 8
2426144 | 1535 | 3600.001.04 Tilluft: 8
2426149 | 436.864 | 3600.001.04 Tilluft: 8
2426162 | 589.036 | 3600.001.04 Tilluft: 8
2426164 | 1535 | 3600.001.04 Tilluft: 8
2426169 | 436.864 | 3600.001.04 Tilluft: 8
2426182 | 589.031 | 3600.001.04 Tilluft: 8
2426184 | 1535 | 3600.001.04 Tilluft: 8
2426189 | 436.864 | 3600.001.04 Tilluft: 8
2426202 | 589.031 | 3600.001.04 Tilluft: 8
2426204 | 1535 | 3600.001.04 Tilluft: 8
2426209 | 436.864 | 3600.001.04 Tilluft: 8
2426222 | 589.031 | 3600.001.04 Tilluft: 8
2426224 | 1535 | 3600.001.04 Tilluft: 8
2426229 | 436.864 | 3600.001.04 Tilluft: 8
2427403 | 798.774 | 3600.001.04 Tilluft: 8
2427452 | 798.765 | 3600.001.04 Tilluft: 8
2427495 | 798.758 | 3600.001.04 Tilluft: 8
2427581 | 315.823 | 3600.001.04 Tilluft: 8
2427624 | 318.37 | 3600.001.04 Tilluft: 8
2427667 | 320.914 | 3600.001.04 Tilluft: 8
2427710 | 323.461 | 3600.001.04 Tilluft: 8
2454052 | 794 | 3600.001.04 Tilluft: 8
2459235 | 635.3 | 3600.001.08 Spesialavtrekk: 25
2496832 | 2885.79 | 3600.001.01 Inntak: 17
2496987 | 72.429 | 3600.001.01 Inntak: 24
2511184 | 1687.5 | 3600.001.04 Tilluft: 3
2511190 | 1687.5 | 3600.001.05 Avtrekk: 16
2511805 | 324.587 | 3600.001.04 Tilluft: 8
2575768 | 3210.99 | 3600.001.05 Avtrekk: 7
2578072 | 1094 | 3600.001.04 Tilluft: 8
2587810 | 887.5 | 3600.001.05 Avtrekk: 7
2598151 | 2439.77 | 3600.001.05 Avtrekk: 7
2599272 | 1025.94 | 3600.001.04 Tilluft: 8
2599441 | 1405.43 | 3600.001.04 Tilluft: 8
2599897 | 817.724 | 3600.001.04 Tilluft: 8
2600033 | 3194.06 | 3600.001.05 Avtrekk: 7
2680134 | 390.491 | 3600.001.05 Avtrekk: 7
