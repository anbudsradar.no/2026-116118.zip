Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Round Duct:Sirkulær kanal PVC (16)
Name (Round Duct:Sirkulær kanal PVC:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2166068 | 2177.12 | 3600.001.08 Spesialavtrekk: 24
2166078 | 1374.6 | 3600.001.05 Avtrekk: 7
2166084 | 1354.11 | 3600.001.05 Avtrekk: 7
2194771 | 2647.39 | 3600.001.05 Avtrekk: 7
2195291 | 2647.39 | 3600.001.05 Avtrekk: 7
2220400 | 1158.22 | 3600.001.05 Avtrekk: 7
2220405 | 1160 | 3600.001.05 Avtrekk: 7
2220410 | 1461.64 | 3600.001.08 Spesialavtrekk: 24
2527834 | 401.854 | 3600.001.05 Avtrekk: 7
2527837 | 174.658 | 3600.001.05 Avtrekk: 7
2527969 | 471.136 | 3600.001.05 Avtrekk: 7
2527972 | 162.282 | 3600.001.05 Avtrekk: 7
2572061 | 1020 | 3600.001.05 Avtrekk: 7
2572064 | 2017.26 | 3600.001.05 Avtrekk: 7
2572221 | 574.545 | 3600.001.05 Avtrekk: 7
2572224 | 91.3755 | 3600.001.05 Avtrekk: 7

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (97)
In: 0-Havnivå
Type - Description: Sirkulær kanal syrefast; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal SF 1; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2165454 | 3120 | 3600.001.05 Avtrekk: 7
2165467 | 6632.65 | 3600.001.05 Avtrekk: 7
2165477 | 34149 | 3600.001.08 Spesialavtrekk: 24
2165481 | 42111.7 | 3600.001.08 Spesialavtrekk: 24
2165501 | 817.187 | 3600.001.08 Spesialavtrekk: 24
2165503 | 852.056 | 3600.001.08 Spesialavtrekk: 24
2165505 | 980.845 | 3600.001.08 Spesialavtrekk: 24
2165507 | 945.72 | 3600.001.08 Spesialavtrekk: 24
2165509 | 71775.5 | 3600.001.08 Spesialavtrekk: 24
2165525 | 884.297 | 3600.001.08 Spesialavtrekk: 24
2165527 | 930.743 | 3600.001.08 Spesialavtrekk: 24
2165529 | 822.336 | 3600.001.08 Spesialavtrekk: 24
2165531 | 1023.64 | 3600.001.08 Spesialavtrekk: 24
2165798 | 28434.8 | 3600.001.08 Spesialavtrekk: 24
2165799 | 680.146 | 3600.001.08 Spesialavtrekk: 24
2166062 | 1544.86 | 3600.001.08 Spesialavtrekk: 24
2197175 | 642.657 | 3600.001.08 Spesialavtrekk: 24
2197184 | 441.366 | 3600.001.08 Spesialavtrekk: 24
2197193 | 534.27 | 3600.001.08 Spesialavtrekk: 24
2197202 | 580.722 | 3600.001.08 Spesialavtrekk: 24
2197254 | 529.608 | 3600.001.08 Spesialavtrekk: 24
2197263 | 494.484 | 3600.001.08 Spesialavtrekk: 24
2197272 | 623.272 | 3600.001.08 Spesialavtrekk: 24
2197281 | 658.141 | 3600.001.08 Spesialavtrekk: 24
2229515 | 5636.27 | 3600.001.05 Avtrekk: 7
2303997 | 1022.5 | 3600.001.08 Spesialavtrekk: 24
2509016 | 471.381 | 3600.001.05 Avtrekk: 7
2509018 | 372.165 | 3600.001.05 Avtrekk: 7
2509025 | 1490.66 | 3600.001.05 Avtrekk: 7
2509027 | 3360.75 | 3600.001.05 Avtrekk: 7
2509029 | 2188.11 | 3600.001.05 Avtrekk: 7
2509033 | 993.589 | 3600.001.05 Avtrekk: 7
2509059 | 471.381 | 3600.001.05 Avtrekk: 7
2509061 | 372.165 | 3600.001.05 Avtrekk: 7
2509068 | 1490.66 | 3600.001.05 Avtrekk: 7
2509070 | 3360.75 | 3600.001.05 Avtrekk: 7
2509072 | 2188.11 | 3600.001.05 Avtrekk: 7
2509076 | 993.589 | 3600.001.05 Avtrekk: 7
2509258 | 471.381 | 3600.001.05 Avtrekk: 7
2509260 | 372.165 | 3600.001.05 Avtrekk: 7
2509267 | 1490.66 | 3600.001.05 Avtrekk: 7
2509269 | 3360.75 | 3600.001.05 Avtrekk: 7
2509271 | 2188.11 | 3600.001.05 Avtrekk: 7
2509275 | 993.589 | 3600.001.05 Avtrekk: 7
2509310 | 471.381 | 3600.001.05 Avtrekk: 7
2509312 | 372.165 | 3600.001.05 Avtrekk: 7
2509319 | 1490.66 | 3600.001.05 Avtrekk: 7
2509321 | 3460.75 | 3600.001.05 Avtrekk: 7
2509323 | 2188.11 | 3600.001.05 Avtrekk: 7
2509327 | 993.589 | 3600.001.05 Avtrekk: 7
2509364 | 2377.87 | 3600.001.05 Avtrekk: 7
2509366 | 2109.52 | 3600.001.05 Avtrekk: 7
2509368 | 1024.56 | 3600.001.05 Avtrekk: 7
2509370 | 2973.13 | 3600.001.05 Avtrekk: 7
2509375 | 117.133 | 3600.001.05 Avtrekk: 7
2509381 | 1427.88 | 3600.001.05 Avtrekk: 7
2509384 | 3410.64 | 3600.001.05 Avtrekk: 7
2509416 | 1150.86 | 3600.001.05 Avtrekk: 7
2509419 | 5735.14 | 3600.001.05 Avtrekk: 7
2509421 | 2381.38 | 3600.001.05 Avtrekk: 7
2509425 | 1264.59 | 3600.001.05 Avtrekk: 7
2509689 | 61.8559 | 3600.001.05 Avtrekk: 7
2510176 | 2585.5 | 3600.001.05 Avtrekk: 7
2510178 | 1893.37 | 3600.001.05 Avtrekk: 7
2510180 | 1286.59 | 3600.001.05 Avtrekk: 7
2510182 | 2638.16 | 3600.001.05 Avtrekk: 7
2510187 | 180.352 | 3600.001.05 Avtrekk: 7
2510191 | 1193.61 | 3600.001.05 Avtrekk: 7
2510194 | 4001.03 | 3600.001.05 Avtrekk: 7
2510228 | 594.698 | 3600.001.05 Avtrekk: 7
2510231 | 4066.87 | 3600.001.05 Avtrekk: 7
2510233 | 4765.37 | 3600.001.05 Avtrekk: 7
2510237 | 984.589 | 3600.001.05 Avtrekk: 7
2510339 | 260.998 | 3600.001.05 Avtrekk: 7
2510396 | 3555.48 | 3600.001.08 Spesialavtrekk: 24
2510398 | 3640.24 | 3600.001.08 Spesialavtrekk: 24
2510400 | 108.9 | 3600.001.08 Spesialavtrekk: 24
2510764 | 1590.49 | 3600.001.08 Spesialavtrekk: 24
2510766 | 1940.76 | 3600.001.08 Spesialavtrekk: 24
2510770 | 3885.5 | 3600.001.08 Spesialavtrekk: 24
2511076 | 230.863 | 3600.001.08 Spesialavtrekk: 24
2524366 | 197.52 | 3600.001.08 Spesialavtrekk: 24
2525584 | 427.239 | 3600.001.05 Avtrekk: 7
2525759 | 14048.1 | 3600.001.05 Avtrekk: 7
2526331 | 42319.4 | 3600.001.05 Avtrekk: 7
2526751 | 255.88 | 3600.001.05 Avtrekk: 7
2526927 | 357.5 | 3600.001.05 Avtrekk: 7
2526937 | 14048.1 | 3600.001.05 Avtrekk: 7
2526939 | 357.5 | 3600.001.05 Avtrekk: 7
2527128 | 24594.7 | 3600.001.05 Avtrekk: 7
2527634 | 1641.86 | 3600.001.05 Avtrekk: 7
2527643 | 1641.86 | 3600.001.05 Avtrekk: 7
2527848 | 956.152 | 3600.001.05 Avtrekk: 7
2527983 | 17702.5 | 3600.001.05 Avtrekk: 7
2570755 | 46309.1 | 3600.001.05 Avtrekk: 7
2570879 | 20074.5 | 3600.001.05 Avtrekk: 7
2572235 | 361.657 | 3600.001.05 Avtrekk: 7

# IfcFlowTerminal: Netting-A:Netting-A-250 2, Netting-A:Netting-A-250 2:2572066
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-250 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowTerminal: Netting-A:Netting-A-315 2 (4)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-315 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-315 2:...)
2509022
2509065
2509264
2509316

# IfcFlowTerminal: Netting-A:Netting-A-400 2 (3)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-400 2; sets with these values: 2
Name (Netting-A:Netting-A-400 2:...) | Group
2166088 | 3600.001.05 Avtrekk: 7
2166089 | 3600.001.05 Avtrekk: 7
2166090 | 3600.001.08 Spesialavtrekk: 24

# IfcFlowTerminal: Netting-A:Netting-A-500 2 (6)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-500 2:...)
2194654
2195295
2509374
2509418
2510186
2510230

# IfcFlowTerminal: SI-T_V:SI-T/V-1212 (11)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1212; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1212:...)
2165821
2165828
2165879
2165884
2165889
2165894
2165948
2166119
2181884
2181923
2181963

# IfcFlowTerminal: SI-T_V:SI-T/V-1218 (4)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1218; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1218:...)
2165812
2165959
2181810
2181847

# IfcFlowTerminal: SI-T_V:SI-T/V-1224 2, SI-T_V:SI-T/V-1224 2:2222404
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1224 2; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcFlowTerminal: UPK-H-K-B-400:UPK-H-K-B-400 (8)
In: 0-Havnivå
Type - Description: Exhaust diffusor; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: UPK-H-K-B-400; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 24
Name (UPK-H-K-B-400:UPK-H-K-B-400:...)
2165780
2165781
2165782
2165783
2165895
2165896
2165897
2165898
