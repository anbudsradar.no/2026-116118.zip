Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c04e82b7-d741-4bb0-b665-850c62e824b8, VersionGUID: 8506877b-761f-45d8-aa30-5a952f8ef247, NumberOfSaves: 1870], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Bekkelaget Renseanlegg - Biohall 4.ifc
Time: 2026-09-22T13:11:39+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENU) - 26.4.10.8

# IfcProject, 52502296
LongName: Bekkelaget RA - Oppgradering 2000-anlegget; Phase: ---

# IfcSite, Default
RefLatitude: 49, 0, 24, 428900; RefLongitude: 9, 7, 59, 338362; RefElevation: 0 mm

# IfcBuilding, Bygning (endres i Project Information)
LongName: Bygning (endres i Project Information)
Pset_BuildingCommon - NumberOfStoreys: 11

# IfcBuildingStorey (11)
In: Bygning (endres i Project Information)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
+00,00 | +00,00 | -8.84387e-11
Plan 01 | Plan 01 | 0
0-Havnivå | 0-Havnivå | 0
PLAN +2,50 | PLAN +2,50 | 2500
Plan 02 | Plan 02 | 3500
PLAN +5,00 | PLAN +5,00 | 5000
Plan 03 | Plan 03 | 7000
PLAN +7,80 | PLAN +7,80 | 7800
PLAN +10,50 | PLAN +10,50 | 10500
PLAN +13,40 | PLAN +13,40 | 13400
PLAN +16,00 | PLAN +16,00 | 16000

# IfcBuildingElementProxy: DRU:DRU 250, DRU:DRU 250:2572063
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 250; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: DRU:DRU 400 (11)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 400; sets with these values: 2
Name (DRU:DRU 400:...) | Group
2197178 | 3600.001.08 Spesialavtrekk: 24
2197187 | 3600.001.08 Spesialavtrekk: 24
2197196 | 3600.001.08 Spesialavtrekk: 24
2197205 | 3600.001.08 Spesialavtrekk: 24
2197257 | 3600.001.08 Spesialavtrekk: 24
2197266 | 3600.001.08 Spesialavtrekk: 24
2197275 | 3600.001.08 Spesialavtrekk: 24
2197284 | 3600.001.08 Spesialavtrekk: 24
2220403 | 3600.001.05 Avtrekk: 7
2220408 | 3600.001.05 Avtrekk: 7
2220413 | 3600.001.08 Spesialavtrekk: 24

# IfcBuildingElementProxy: IRIS:IRIS-315 2 (21)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-315 2; sets with these values: 2
Name (IRIS:IRIS-315 2:...) | Group
2165977 | 3600.001.04 Tilluft: 8
2165983 | 3600.001.04 Tilluft: 8
2165989 | 3600.001.04 Tilluft: 8
2165995 | 3600.001.04 Tilluft: 8
2166001 | 3600.001.04 Tilluft: 8
2166006 | 3600.001.04 Tilluft: 8
2166009 | 3600.001.04 Tilluft: 8
2166012 | 3600.001.04 Tilluft: 8
2166015 | 3600.001.04 Tilluft: 8
2166122 | 3600.001.04 Tilluft: 8
2181825 | 3600.001.04 Tilluft: 8
2181862 | 3600.001.04 Tilluft: 8
2181899 | 3600.001.04 Tilluft: 8
2181938 | 3600.001.04 Tilluft: 8
2181978 | 3600.001.04 Tilluft: 8
2191446 | 3600.001.04 Tilluft: 8
2191516 | 3600.001.04 Tilluft: 8
2509035 | 3600.001.05 Avtrekk: 7
2509078 | 3600.001.05 Avtrekk: 7
2509277 | 3600.001.05 Avtrekk: 7
2509329 | 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: IRIS:IRIS-400 2, IRIS:IRIS-400 2:2222407
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-400 2; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: IRIS:IRIS-500 2 (6)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: IRIS-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (IRIS:IRIS-500 2:...)
2509383
2509427
2510193
2510239
2527637
2527646

# IfcBuildingElementProxy: LKR-1200:LKR-800-1200, LKR-1200:LKR-800-1200:2203937
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: LKR-800-1200; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 24

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500, LKR-1500:LKR-1000-1500:2203968
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500, LKR-1500:LKR-1000-1500:2165810
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: Toposolid:Toposolid 1, Toposolid:Toposolid 1:2375736
In: Plan 01
Material: Glass
Pset_BuildingElementProxyCommon - Reference: Toposolid 1; sets with these values: 2
Pset_ProductRequirements - Name: Terrengmodell - Biohall 1 5

# IfcDistributionPort (845)
Description: Flow
Name | FlowDirection | Group
InPort_2570976_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2165454_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2165454_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2187601_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2165467_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526758_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2187601_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2165467_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2565766_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165471_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165810_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181932_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181893_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_5 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181856_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_6 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181819_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165926_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165928_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_11 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165968_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165471_12 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165473_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567991_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567993_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165473_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165477_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2511016_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2524375_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165477_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165477_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165533_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165477_3 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165899_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165477_4 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165901_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165477_5 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165903_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165481_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165778_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510467_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165481_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165481_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165517_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165481_3 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165519_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165481_4 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165521_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165481_5 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165523_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165501_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197284_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165517_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165501_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165503_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197275_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165519_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165503_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165505_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197266_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165521_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165505_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165523_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165507_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165507_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197257_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2203937_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165509_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165509_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2186850_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165509_4 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510512_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165509_5 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2511083_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165525_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197205_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165533_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165525_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165527_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197196_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165903_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165527_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165529_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197178_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165901_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165529_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165531_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197187_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165899_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165531_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197281_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165780_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197272_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165781_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197263_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165782_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197254_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165783_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165802_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165798_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165798_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2192440_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165798_3 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2166064_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165799_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165802_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2511016_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165799_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165810_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2304107_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165812_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165916_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165936_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165813_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165813_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165983_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165817_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165815_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165815_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165928_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165981_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165817_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165821_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165819_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165819_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165946_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165946_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165822_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165822_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165989_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165826_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165824_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165824_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165926_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165987_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165826_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165828_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165918_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165995_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165829_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165829_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165833_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165833_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165831_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165831_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565760_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166048_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165875_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165875_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2216045_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165879_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165877_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165877_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166015_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166044_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165880_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165880_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2216047_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166012_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165882_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165882_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166044_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165884_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166010_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166040_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165885_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165885_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2216049_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166009_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165887_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165887_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166040_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165889_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166007_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166036_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165890_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165890_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566117_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165894_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165892_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165892_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166006_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2197202_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165895_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197193_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165896_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197184_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165897_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197175_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2165898_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2165916_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165936_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165918_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165942_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165942_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165993_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165948_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165955_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166001_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165949_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165949_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165953_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165953_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165951_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165951_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565762_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165955_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165957_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165957_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165999_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165959_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165966_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165977_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165960_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165960_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165964_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165964_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165962_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165962_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165968_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165966_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165970_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165970_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165975_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165975_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165977_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165983_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165981_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165989_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165987_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165993_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2165995_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2165999_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166001_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166006_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166004_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166004_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166036_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166007_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166009_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166010_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166012_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166015_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166013_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166013_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166048_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566564_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166026_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166026_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2197013_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566568_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166026_3 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166064_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2166062_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2166062_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2166070_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2166070_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2166068_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2166068_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2220413_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2527844_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2166078_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2166078_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220408_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527979_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2166084_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2166084_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220403_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220405_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2166088_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220400_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2166089_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220410_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2166090_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2166131_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166115_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166115_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566119_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166122_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166117_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166117_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166131_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166119_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166120_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166120_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166122_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2166137_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2524719_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2197013_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2166137_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181810_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181817_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181825_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181811_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181811_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181815_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181815_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181813_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181813_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181819_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181817_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181821_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181821_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181823_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181823_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181825_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181847_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181854_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181862_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181848_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181848_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181852_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181852_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181850_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181850_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181856_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181854_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181858_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181858_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181860_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181860_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181862_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181884_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181891_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181899_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181885_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181885_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181889_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181889_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181887_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181887_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181893_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181891_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181895_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181895_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181897_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181897_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181899_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181923_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181930_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181938_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181924_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181924_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181928_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181928_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181926_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181926_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181932_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181930_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181934_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181934_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181936_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181936_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181938_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181963_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181970_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181978_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181964_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181964_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181968_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181968_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181966_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181966_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565764_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181970_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181974_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181974_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181976_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2181976_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2181978_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567972_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2187847_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2187847_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567993_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2216045_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2187847_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2216047_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2187847_9 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2216049_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2187847_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2190136_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2191446_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2191612_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2190136_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2191625_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2190204_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2190204_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2223364_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2191446_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2191443_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2191443_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510631_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2191516_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222840_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2222940_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2191516_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2194771_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2194654_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527622_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2194771_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2195291_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2195295_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527313_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2195291_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2197178_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197175_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197187_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197184_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197196_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197193_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197205_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197202_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197257_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197254_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197266_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197263_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197275_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197272_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2197284_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2197281_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2303997_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2203937_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2587810_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2203968_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2203968_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570755_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220403_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220400_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220408_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220405_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220413_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2220410_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2222402_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2524974_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2222407_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222402_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2222404_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222405_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2222405_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222407_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2222840_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566564_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2526174_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222940_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2223364_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2525864_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2525591_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2229515_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2229515_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562161_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2229515_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526934_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2229515_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526943_1 | SOURCE | 3600.001.05 Avtrekk: 7
OutPort_2303997_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2304107_0 | SINK | 3600.001.04 Tilluft: 8
InPort_2509020_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509016_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509016_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509035_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509018_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509020_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509023_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509018_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509033_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509022_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509025_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509023_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509909_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509025_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509890_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509027_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509027_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509913_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509029_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509909_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509913_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509029_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509035_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509033_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509063_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509059_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509059_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509078_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509061_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509063_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509066_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509061_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509076_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509065_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509068_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509066_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509996_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509068_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509977_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509070_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509070_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510000_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509072_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509996_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510000_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509072_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509078_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509076_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509262_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509258_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509258_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509277_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509260_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509262_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509265_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509260_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509275_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509264_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509267_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509265_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510071_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509267_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510053_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509269_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509269_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510075_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509271_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510071_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510075_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509271_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509277_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509275_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509314_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509310_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509310_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509329_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509312_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509314_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509317_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509312_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509327_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509316_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509319_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509317_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510159_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509319_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570790_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509321_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509321_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510163_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509323_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510159_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510163_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509323_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509329_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509327_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509692_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509364_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509364_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509386_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509366_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509379_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509388_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509366_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509372_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509368_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509368_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509383_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509370_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509372_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509377_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509370_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509381_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509374_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509375_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509377_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509379_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509375_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509383_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509381_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509386_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509384_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509384_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509388_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509416_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509427_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509423_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509416_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509425_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509418_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509419_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509642_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562046_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509419_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572238_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509421_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509421_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509423_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509427_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509425_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509642_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572235_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570760_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509689_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2509689_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509692_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570755_6 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509890_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570755_5 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2509977_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570755_4 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510053_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510342_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510176_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510176_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510196_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510178_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510198_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510200_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510178_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510184_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510180_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510180_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510193_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510182_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510184_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510189_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510182_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510191_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510186_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510187_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510189_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510198_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510187_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510193_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510191_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510196_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510194_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510194_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510200_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510228_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510239_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510235_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510228_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510237_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510230_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510231_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510290_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570792_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510231_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510290_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510233_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510233_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510235_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510239_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510237_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570888_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510339_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510339_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2510342_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2510396_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510406_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510512_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510396_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510406_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510398_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510398_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510402_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510402_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510400_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510400_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510467_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510559_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510715_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510561_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510559_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510563_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510561_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510567_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510563_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510565_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510567_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510631_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510565_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510712_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565758_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2510715_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2510712_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2511079_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510764_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510764_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510774_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510766_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2524371_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510772_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510766_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510770_0 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510772_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2510774_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2510770_1 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2511083_2 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2511076_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2511076_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2511079_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2524371_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2524366_0 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2524366_1 | SINK | 3600.001.08 Spesialavtrekk: 24
OutPort_2524375_2 | SOURCE | 3600.001.08 Spesialavtrekk: 24
InPort_2524719_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2524714_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2524714_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2524723_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2524723_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566263_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2524974_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2527730_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2526800_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2525584_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2525584_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2525591_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527646_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2525759_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2525759_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527313_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2525864_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2526170_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2526170_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2526167_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2526167_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2526174_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2526754_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526331_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526331_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527986_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526751_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526754_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526758_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526751_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527848_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526800_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526934_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526927_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526927_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527309_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527637_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526937_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526937_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527620_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526943_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526939_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526939_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2526941_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2526941_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527634_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527620_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527128_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527128_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527622_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527309_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527643_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527634_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527637_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527643_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527646_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527730_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566568_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2527840_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527834_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527834_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527844_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527851_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527837_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527837_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527840_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527851_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527848_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527983_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527851_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527975_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527969_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527969_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527979_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527986_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527972_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527972_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527975_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2527986_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2527983_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570755_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562046_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2567991_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565726_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2565726_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565766_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2565758_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565726_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2565760_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565726_11 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2565762_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565726_12 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2565764_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2565726_13 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566380_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566032_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566032_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567972_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566117_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566032_6 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566119_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566032_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566263_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566380_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2570755_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570796_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570755_7 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570760_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570879_4 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570790_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570879_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570792_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570796_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570879_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570879_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570976_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570879_5 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570888_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572063_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572061_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572061_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572066_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572064_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572063_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572231_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572064_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572227_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572221_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572221_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572231_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572238_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572224_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572224_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572227_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572235_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572238_2 | SOURCE | 3600.001.05 Avtrekk: 7
OutPort_2587810_0 | SOURCE | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: Lindab ESU:ESU (2)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: ESU; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (Lindab ESU:ESU:...)
2191612
2191625

# IfcFlowFitting: Lindab TCPU:TCPU (3)
In: 0-Havnivå
Type - Description: T-stykke, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: TCPU; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Lindab TCPU:TCPU:...)
2527851
2527986
2572238

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (46)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2187601 | 3600.001.05 Avtrekk: 7
2509020 | 3600.001.05 Avtrekk: 7
2509023 | 3600.001.05 Avtrekk: 7
2509063 | 3600.001.05 Avtrekk: 7
2509066 | 3600.001.05 Avtrekk: 7
2509262 | 3600.001.05 Avtrekk: 7
2509265 | 3600.001.05 Avtrekk: 7
2509314 | 3600.001.05 Avtrekk: 7
2509317 | 3600.001.05 Avtrekk: 7
2509372 | 3600.001.05 Avtrekk: 7
2509377 | 3600.001.05 Avtrekk: 7
2509379 | 3600.001.05 Avtrekk: 7
2509386 | 3600.001.05 Avtrekk: 7
2509388 | 3600.001.05 Avtrekk: 7
2509423 | 3600.001.05 Avtrekk: 7
2509642 | 3600.001.05 Avtrekk: 7
2509692 | 3600.001.05 Avtrekk: 7
2509909 | 3600.001.05 Avtrekk: 7
2509913 | 3600.001.05 Avtrekk: 7
2509996 | 3600.001.05 Avtrekk: 7
2510000 | 3600.001.05 Avtrekk: 7
2510071 | 3600.001.05 Avtrekk: 7
2510075 | 3600.001.05 Avtrekk: 7
2510159 | 3600.001.05 Avtrekk: 7
2510163 | 3600.001.05 Avtrekk: 7
2510184 | 3600.001.05 Avtrekk: 7
2510189 | 3600.001.05 Avtrekk: 7
2510196 | 3600.001.05 Avtrekk: 7
2510198 | 3600.001.05 Avtrekk: 7
2510200 | 3600.001.05 Avtrekk: 7
2510235 | 3600.001.05 Avtrekk: 7
2510290 | 3600.001.05 Avtrekk: 7
2510342 | 3600.001.05 Avtrekk: 7
2524719 | 3600.001.04 Tilluft: 8
2526758 | 3600.001.05 Avtrekk: 7
2526941 | 3600.001.05 Avtrekk: 7
2527309 | 3600.001.05 Avtrekk: 7
2527313 | 3600.001.05 Avtrekk: 7
2527620 | 3600.001.05 Avtrekk: 7
2527622 | 3600.001.05 Avtrekk: 7
2527840 | 3600.001.05 Avtrekk: 7
2527844 | 3600.001.05 Avtrekk: 7
2527975 | 3600.001.05 Avtrekk: 7
2527979 | 3600.001.05 Avtrekk: 7
2572227 | 3600.001.05 Avtrekk: 7
2572231 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (14)
Type - Description: Bend, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | In | Group
2165802 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2166070 | Plan 01 | 3600.001.08 Spesialavtrekk: 24
2510402 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2510406 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2510467 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2510772 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2510774 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2511016 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2511079 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2524371 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2524375 | 0-Havnivå | 3600.001.08 Spesialavtrekk: 24
2525591 | 0-Havnivå | 3600.001.05 Avtrekk: 7
2526754 | 0-Havnivå | 3600.001.05 Avtrekk: 7
2526800 | 0-Havnivå | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (8)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...)
2510561
2510567
2510631
2510715
2524723
2526170
2526174
2567993

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv (29)
In: 0-Havnivå
Type - Description: Bend, Sirkulær Galv; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001 Galv; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv:...)
2165817
2165826
2165833
2165936
2165942
2165946
2165953
2165957
2165964
2165970
2166036
2166040
2166044
2166048
2166131
2181815
2181821
2181852
2181858
2181889
2181895
2181928
2181934
2181968
2181974
2197013
2223364
2524974
2567991

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001 (4)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Name (magicirc_plug_001:magicirc_plug_001:...) | Group
2165778 | 3600.001.08 Spesialavtrekk: 24
2186850 | 3600.001.08 Spesialavtrekk: 24
2192440 | 3600.001.08 Spesialavtrekk: 24
2562161 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_reduction_001:magicirc_reduction_001 (6)
In: 0-Havnivå
Type - Description: Overgang, Sirkulær; Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_001; sets with these values: 2
Name (magicirc_reduction_001:magicirc_reduction_001:...) | Group
2565766 | 3600.001.04 Tilluft: 8
2566380 | 3600.001.04 Tilluft: 8
2566564 | 3600.001.04 Tilluft: 8
2567972 | 3600.001.04 Tilluft: 8
2570796 | 3600.001.05 Avtrekk: 7
2570976 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (10)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2509890
2509977
2510053
2526934
2526943
2562046
2570760
2570790
2570792
2570888

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (11)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 24
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2165517
2165519
2165521
2165523
2165533
2165899
2165901
2165903
2166064
2510512
2511083

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (17)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2165926
2165928
2165968
2181819
2181856
2181893
2181932
2216045
2216047
2216049
2565758
2565760
2565762
2565764
2566117
2566119
2566568

# IfcFlowSegment: Round Duct:Sirkulær kanal Galv (80)
In: 0-Havnivå
Type - Description: Sirkulær kanal, Galvanisert stål; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal Galv; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal Galv:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2165471 | 46293.1 | 3600.001.04 Tilluft: 8
2165473 | 6757.29 | 3600.001.04 Tilluft: 8
2165813 | 481.414 | 3600.001.04 Tilluft: 8
2165815 | 737.276 | 3600.001.04 Tilluft: 8
2165819 | 1600.71 | 3600.001.04 Tilluft: 8
2165822 | 475.772 | 3600.001.04 Tilluft: 8
2165824 | 738.891 | 3600.001.04 Tilluft: 8
2165829 | 493.387 | 3600.001.04 Tilluft: 8
2165831 | 836.202 | 3600.001.04 Tilluft: 8
2165875 | 53.021 | 3600.001.04 Tilluft: 8
2165877 | 600.302 | 3600.001.04 Tilluft: 8
2165880 | 53.0214 | 3600.001.04 Tilluft: 8
2165882 | 478.893 | 3600.001.04 Tilluft: 8
2165885 | 53.0218 | 3600.001.04 Tilluft: 8
2165887 | 481.243 | 3600.001.04 Tilluft: 8
2165890 | 138.025 | 3600.001.04 Tilluft: 8
2165892 | 535.771 | 3600.001.04 Tilluft: 8
2165916 | 1000.71 | 3600.001.04 Tilluft: 8
2165918 | 1600.71 | 3600.001.04 Tilluft: 8
2165949 | 444.018 | 3600.001.04 Tilluft: 8
2165951 | 839.594 | 3600.001.04 Tilluft: 8
2165955 | 1600.71 | 3600.001.04 Tilluft: 8
2165960 | 462.575 | 3600.001.04 Tilluft: 8
2165962 | 737.276 | 3600.001.04 Tilluft: 8
2165966 | 1000.71 | 3600.001.04 Tilluft: 8
2165975 | 460.923 | 3600.001.04 Tilluft: 8
2165981 | 442.084 | 3600.001.04 Tilluft: 8
2165987 | 446.202 | 3600.001.04 Tilluft: 8
2165993 | 431.847 | 3600.001.04 Tilluft: 8
2165999 | 477.494 | 3600.001.04 Tilluft: 8
2166004 | 472.229 | 3600.001.04 Tilluft: 8
2166007 | 526.757 | 3600.001.04 Tilluft: 8
2166010 | 509.107 | 3600.001.04 Tilluft: 8
2166013 | 467.698 | 3600.001.04 Tilluft: 8
2166026 | 3284.8 | 3600.001.04 Tilluft: 8
2166115 | 138.025 | 3600.001.04 Tilluft: 8
2166117 | 481.243 | 3600.001.04 Tilluft: 8
2166120 | 586.757 | 3600.001.04 Tilluft: 8
2166137 | 5606.32 | 3600.001.04 Tilluft: 8
2181811 | 462.575 | 3600.001.04 Tilluft: 8
2181813 | 737.276 | 3600.001.04 Tilluft: 8
2181817 | 1000.71 | 3600.001.04 Tilluft: 8
2181823 | 460.923 | 3600.001.04 Tilluft: 8
2181848 | 462.575 | 3600.001.04 Tilluft: 8
2181850 | 737.276 | 3600.001.04 Tilluft: 8
2181854 | 1000.71 | 3600.001.04 Tilluft: 8
2181860 | 460.923 | 3600.001.04 Tilluft: 8
2181885 | 462.575 | 3600.001.04 Tilluft: 8
2181887 | 737.276 | 3600.001.04 Tilluft: 8
2181891 | 1600.71 | 3600.001.04 Tilluft: 8
2181897 | 460.923 | 3600.001.04 Tilluft: 8
2181924 | 462.575 | 3600.001.04 Tilluft: 8
2181926 | 737.276 | 3600.001.04 Tilluft: 8
2181930 | 1600.71 | 3600.001.04 Tilluft: 8
2181936 | 460.923 | 3600.001.04 Tilluft: 8
2181964 | 462.575 | 3600.001.04 Tilluft: 8
2181966 | 837.51 | 3600.001.04 Tilluft: 8
2181970 | 1600.71 | 3600.001.04 Tilluft: 8
2181976 | 460.923 | 3600.001.04 Tilluft: 8
2187847 | 33871.1 | 3600.001.04 Tilluft: 8
2190136 | 24260 | 3600.001.04 Tilluft: 8
2190204 | 23592.5 | 3600.001.04 Tilluft: 8
2191443 | 399 | 3600.001.04 Tilluft: 8
2222402 | 765.193 | 3600.001.04 Tilluft: 8
2222405 | 594.234 | 3600.001.04 Tilluft: 8
2222840 | 3523.76 | 3600.001.04 Tilluft: 8
2222940 | 1533.44 | 3600.001.04 Tilluft: 8
2304107 | 887.5 | 3600.001.04 Tilluft: 8
2510559 | 1968.73 | 3600.001.04 Tilluft: 8
2510563 | 3580.53 | 3600.001.04 Tilluft: 8
2510565 | 2255.4 | 3600.001.04 Tilluft: 8
2510712 | 107.177 | 3600.001.04 Tilluft: 8
2524714 | 363.73 | 3600.001.04 Tilluft: 8
2525864 | 5954.52 | 3600.001.04 Tilluft: 8
2526167 | 1174.47 | 3600.001.04 Tilluft: 8
2527730 | 258.978 | 3600.001.04 Tilluft: 8
2565726 | 24806 | 3600.001.04 Tilluft: 8
2566032 | 25099 | 3600.001.04 Tilluft: 8
2566263 | 1480.21 | 3600.001.04 Tilluft: 8
2587810 | 887.5 | 3600.001.05 Avtrekk: 7

# IfcFlowSegment: Round Duct:Sirkulær kanal PVC (16)
In: 0-Havnivå
Type - Description: Sirkulær kanal, PVC; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal PVC; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
