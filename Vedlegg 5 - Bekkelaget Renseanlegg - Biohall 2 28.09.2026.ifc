Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (109)
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2209265 | 658.141 | 3600.001.08 Spesialavtrekk: 20
2209948 | 19377 | 3600.001.05 Avtrekk: 7
2227369 | 15493.4 | 3600.001.08 Spesialavtrekk: 20
2227553 | 913.392 | 3600.001.08 Spesialavtrekk: 20
2229124 | 811.254 | 3600.001.05 Avtrekk: 7
2392865 | 33947.7 | 3600.001.08 Spesialavtrekk: 20
2491820 | 638.793 | 3600.001.05 Avtrekk: 7
2491823 | 3603.21 | 3600.001.05 Avtrekk: 7
2491825 | 5197.04 | 3600.001.05 Avtrekk: 7
2491831 | 916.743 | 3600.001.05 Avtrekk: 7
2492089 | 2711.62 | 3600.001.05 Avtrekk: 7
2492091 | 2257.96 | 3600.001.05 Avtrekk: 7
2492093 | 876.834 | 3600.001.05 Avtrekk: 7
2492097 | 957.565 | 3600.001.05 Avtrekk: 7
2492102 | 2140.71 | 3600.001.05 Avtrekk: 7
2492106 | 842.844 | 3600.001.05 Avtrekk: 7
2492115 | 3476.53 | 3600.001.05 Avtrekk: 7
2493606 | 786.124 | 3600.001.05 Avtrekk: 7
2493610 | 285.323 | 3600.001.05 Avtrekk: 7
2493617 | 1665.26 | 3600.001.05 Avtrekk: 7
2493619 | 3526.09 | 3600.001.05 Avtrekk: 7
2493621 | 678.846 | 3600.001.05 Avtrekk: 7
2493624 | 2366.05 | 3600.001.05 Avtrekk: 7
2493628 | 2227.93 | 3600.001.05 Avtrekk: 7
2493809 | 777.787 | 3600.001.05 Avtrekk: 7
2493812 | 4130.47 | 3600.001.05 Avtrekk: 7
2493816 | 984.589 | 3600.001.05 Avtrekk: 7
2493819 | 519.119 | 3600.001.05 Avtrekk: 7
2493823 | 3855.45 | 3600.001.05 Avtrekk: 7
2495253 | 142.454 | 3600.001.05 Avtrekk: 7
2495791 | 786.124 | 3600.001.05 Avtrekk: 7
2495793 | 285.323 | 3600.001.05 Avtrekk: 7
2495798 | 1665.26 | 3600.001.05 Avtrekk: 7
2495800 | 3526.09 | 3600.001.05 Avtrekk: 7
2495802 | 678.846 | 3600.001.05 Avtrekk: 7
2495805 | 2366.05 | 3600.001.05 Avtrekk: 7
2495809 | 2227.93 | 3600.001.05 Avtrekk: 7
2495859 | 786.124 | 3600.001.05 Avtrekk: 7
2495861 | 285.323 | 3600.001.05 Avtrekk: 7
2495866 | 1665.26 | 3600.001.05 Avtrekk: 7
2495868 | 3526.09 | 3600.001.05 Avtrekk: 7
2495870 | 678.846 | 3600.001.05 Avtrekk: 7
2495873 | 2366.05 | 3600.001.05 Avtrekk: 7
2495877 | 2227.93 | 3600.001.05 Avtrekk: 7
2495925 | 786.124 | 3600.001.05 Avtrekk: 7
2495927 | 285.324 | 3600.001.05 Avtrekk: 7
2495932 | 1665.26 | 3600.001.05 Avtrekk: 7
2495934 | 3526.09 | 3600.001.05 Avtrekk: 7
2495936 | 678.846 | 3600.001.05 Avtrekk: 7
2495939 | 2366.05 | 3600.001.05 Avtrekk: 7
2495943 | 2227.93 | 3600.001.05 Avtrekk: 7
2496038 | 219.375 | 3600.001.05 Avtrekk: 7
2496082 | 219.375 | 3600.001.05 Avtrekk: 7
2496126 | 219.375 | 3600.001.05 Avtrekk: 7
2496170 | 320.579 | 3600.001.05 Avtrekk: 7
2496216 | 2282.94 | 3600.001.05 Avtrekk: 7
2496218 | 2166.04 | 3600.001.05 Avtrekk: 7
2496220 | 913.061 | 3600.001.05 Avtrekk: 7
2496222 | 1436.14 | 3600.001.05 Avtrekk: 7
2496227 | 212.049 | 3600.001.05 Avtrekk: 7
2496233 | 1193.61 | 3600.001.05 Avtrekk: 7
2496236 | 4773.43 | 3600.001.05 Avtrekk: 7
2496619 | 271.39 | 3600.001.05 Avtrekk: 7
2502618 | 548.54 | 3600.001.05 Avtrekk: 7
2514649 | 518.132 | 3600.001.05 Avtrekk: 7
2514733 | 1111.84 | 3600.001.05 Avtrekk: 7
2514835 | 991.613 | 3600.001.05 Avtrekk: 7
2515416 | 24301.5 | 3600.001.05 Avtrekk: 7
2516763 | 1006.55 | 3600.001.05 Avtrekk: 7
2516886 | 12623.8 | 3600.001.05 Avtrekk: 7
2516989 | 750.883 | 3600.001.05 Avtrekk: 7
2517666 | 249.853 | 3600.001.05 Avtrekk: 7
2517749 | 481.495 | 3600.001.05 Avtrekk: 7
2517865 | 391.887 | 3600.001.05 Avtrekk: 7
2518051 | 1538.14 | 3600.001.08 Spesialavtrekk: 20
2518054 | 16.8526 | 3600.001.08 Spesialavtrekk: 20
2528983 | 17702.5 | 3600.001.05 Avtrekk: 7
2529049 | 3731.19 | 3600.001.05 Avtrekk: 7
2562020 | 385.612 | 3600.001.05 Avtrekk: 7
2562757 | 756.515 | 3600.001.05 Avtrekk: 7
2570029 | 46196.6 | 3600.001.05 Avtrekk: 7
2570143 | 3930 | 3600.001.05 Avtrekk: 7
2587792 | 790 | 3600.001.05 Avtrekk: 7
2600625 | 5400 | 3600.001.08 Spesialavtrekk: 20

# IfcFlowTerminal: Netting-A:Netting-A-250 2, Netting-A:Netting-A-250 2:2562766
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-250 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowTerminal: Netting-A:Netting-A-315 2 (4)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-315 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-315 2:...)
2493616
2495797
2495865
2495931

# IfcFlowTerminal: Netting-A:Netting-A-400 2 (3)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-400 2; sets with these values: 2
Name (Netting-A:Netting-A-400 2:...) | Group
2209115 | 3600.001.05 Avtrekk: 7
2209116 | 3600.001.05 Avtrekk: 7
2209117 | 3600.001.08 Spesialavtrekk: 20

# IfcFlowTerminal: Netting-A:Netting-A-500 2 (6)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-500 2:...)
2209216
2209234
2491822
2492101
2493811
2496226

# IfcFlowTerminal: SI-T_V:SI-T/V-1212 (11)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1212; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1212:...)
2209039
2209044
2209049
2209054
2209122
2492496
2492499
2492512
2492561
2492571
2492581

# IfcFlowTerminal: SI-T_V:SI-T/V-1218 (6)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1218; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1218:...)
2221562
2221575
2492491
2492519
2492541
2492551

# IfcFlowTerminal: UPK-H-K-B-400:UPK-H-K-B-400 (8)
In: 0-Havnivå
Type - Description: Exhaust diffusor; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: UPK-H-K-B-400; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (UPK-H-K-B-400:UPK-H-K-B-400:...)
2209025
2209026
2209027
2209028
2209055
2209056
2209057
2209058
