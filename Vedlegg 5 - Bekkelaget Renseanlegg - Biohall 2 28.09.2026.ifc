Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c04e82b7-d741-4bb0-b665-850c62e824b8, VersionGUID: 0e62efc3-157c-450f-8d85-b250ddbc97cd, NumberOfSaves: 1595], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Bekkelaget Renseanlegg - Biohall 2.ifc
Time: 2026-07-02T14:14:48+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENU) - 26.4.10.8

# IfcProject, 52502296
LongName: Bekkelaget RA - Oppgradering 2000-anlegget; Phase: ---

# IfcSite, Default
RefLatitude: 49, 0, 24, 428900; RefLongitude: 9, 7, 59, 338362; RefElevation: 0 mm

# IfcBuilding, Bygning (endres i Project Information)
LongName: Bygning (endres i Project Information)
Pset_BuildingCommon - NumberOfStoreys: 11

# IfcBuildingStorey (11)
In: Bygning (endres i Project Information)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
+00,00 | +00,00 | -8.84387e-11
Plan 01 | Plan 01 | 0
0-Havnivå | 0-Havnivå | 0
PLAN +2,50 | PLAN +2,50 | 2500
Plan 02 | Plan 02 | 3500
PLAN +5,00 | PLAN +5,00 | 5000
Plan 03 | Plan 03 | 7000
PLAN +7,80 | PLAN +7,80 | 7800
PLAN +10,50 | PLAN +10,50 | 10500
PLAN +13,40 | PLAN +13,40 | 13400
PLAN +16,00 | PLAN +16,00 | 16000

# IfcBuildingElementProxy: DRU:DRU 250, DRU:DRU 250:2562761
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 250; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: DRU:DRU 400 (11)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 400; sets with these values: 2
Name (DRU:DRU 400:...) | Group
2209246 | 3600.001.08 Spesialavtrekk: 20
2209249 | 3600.001.08 Spesialavtrekk: 20
2209252 | 3600.001.08 Spesialavtrekk: 20
2209255 | 3600.001.08 Spesialavtrekk: 20
2209258 | 3600.001.08 Spesialavtrekk: 20
2209261 | 3600.001.08 Spesialavtrekk: 20
2209264 | 3600.001.08 Spesialavtrekk: 20
2209267 | 3600.001.08 Spesialavtrekk: 20
2234930 | 3600.001.08 Spesialavtrekk: 20
2234939 | 3600.001.05 Avtrekk: 7
2234948 | 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: IRIS:IRIS-315 2 (23)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-315 2; sets with these values: 2
Name (IRIS:IRIS-315 2:...) | Group
2209067 | 3600.001.04 Tilluft: 8
2209070 | 3600.001.04 Tilluft: 8
2209073 | 3600.001.04 Tilluft: 8
2209076 | 3600.001.04 Tilluft: 8
2209125 | 3600.001.04 Tilluft: 8
2209194 | 3600.001.04 Tilluft: 8
2209195 | 3600.001.04 Tilluft: 8
2221565 | 3600.001.04 Tilluft: 8
2221578 | 3600.001.04 Tilluft: 8
2492528 | 3600.001.04 Tilluft: 8
2492531 | 3600.001.04 Tilluft: 8
2492534 | 3600.001.04 Tilluft: 8
2492537 | 3600.001.04 Tilluft: 8
2492540 | 3600.001.04 Tilluft: 8
2492550 | 3600.001.04 Tilluft: 8
2492560 | 3600.001.04 Tilluft: 8
2492570 | 3600.001.04 Tilluft: 8
2492580 | 3600.001.04 Tilluft: 8
2492590 | 3600.001.04 Tilluft: 8
2493623 | 3600.001.05 Avtrekk: 7
2495804 | 3600.001.05 Avtrekk: 7
2495872 | 3600.001.05 Avtrekk: 7
2495938 | 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: IRIS:IRIS-500 2 (6)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: IRIS-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (IRIS:IRIS-500 2:...)
2491833
2492108
2493818
2496235
2517868
2562022

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500 (2)
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Name (LKR-1500:LKR-1000-1500:...) | Group
2207971 | 3600.001.04 Tilluft: 8
2210212 | 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: Toposolid:Toposolid 1, Toposolid:Toposolid 1:2375704
In: Plan 01
Material: Glass
Pset_BuildingElementProxyCommon - Reference: Toposolid 1; sets with these values: 2
Pset_ProductRequirements - Name: Terrengmodell - Biohall 1 5

# IfcDistributionPort (848)
Description: Flow
Name | FlowDirection | Group
OutPort_2166577_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166577_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166584_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166577_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2513450_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166577_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2518065_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166579_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2513444_2 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2513450_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166579_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2513444_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166596_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166596_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2513509_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2207971_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2454052_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211125_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2207971_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2208975_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528673_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570089_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2208975_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528673_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2208977_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2208977_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528986_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2208979_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2515247_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2515252_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2208979_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2208987_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2496204_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227556_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2208987_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208987_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209005_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208987_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209007_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208987_4 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209009_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208987_5 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209011_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208993_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209267_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209005_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2208993_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208995_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209264_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209007_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2208995_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208997_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209261_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209009_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2208997_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209011_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2208999_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2208999_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209258_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209013_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209255_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209021_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209013_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209015_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209252_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209063_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209015_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209017_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209246_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209061_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209017_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209019_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209249_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209059_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209019_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2392865_5 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209021_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209265_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209025_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209262_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209026_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209259_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209027_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209256_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209028_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209029_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2513505_2 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2513509_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209029_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209029_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227382_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2513505_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209030_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209030_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2213128_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209089_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209035_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209035_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215562_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209039_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209037_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209037_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209076_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209085_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209040_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209040_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215566_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209073_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209042_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209042_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209085_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209044_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209071_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209081_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209045_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209045_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215570_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209070_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209047_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209047_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209081_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209049_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209068_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209077_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209050_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209050_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563174_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209054_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209052_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209052_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209067_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209253_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209055_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209250_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209056_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209247_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209057_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209244_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209058_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2392865_4 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209059_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2392865_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209061_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2392865_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209063_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209067_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209065_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209065_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209077_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209068_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209070_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209071_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209073_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209076_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209074_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209074_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209089_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209093_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2513677_2 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2518061_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209093_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2513677_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209099_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209099_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2234930_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209107_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234939_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529045_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209107_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2209111_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234948_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528979_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209111_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234936_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209115_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234945_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209116_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234927_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209117_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209126_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209118_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209118_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563176_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209125_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209120_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209120_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209126_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209122_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209123_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209123_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209125_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563178_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209166_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209166_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2515252_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215562_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209166_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215566_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209166_9 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215570_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209166_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209172_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209181_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209187_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209172_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209174_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563005_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209181_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209174_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209179_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209187_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209189_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209179_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209183_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209194_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209196_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209183_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209192_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209189_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209194_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209192_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209195_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209301_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215611_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209195_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209198_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2224273_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209217_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209216_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2229131_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209217_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2209235_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209234_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562018_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209235_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2209246_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209244_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209249_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209247_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209252_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209250_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209255_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209253_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209258_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209256_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209261_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209259_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209264_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209262_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209267_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2209265_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2209301_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563592_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2516427_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2209303_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209303_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563359_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2209948_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570156_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570094_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2209948_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2209948_31 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570061_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2209948_32 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570063_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2209948_33 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570065_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2587792_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2210212_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2210212_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570029_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2563007_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493085_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_23 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493138_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_24 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493170_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_25 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493223_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_26 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493265_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_27 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493297_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_28 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493329_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211125_29 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2213128_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2392865_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2517603_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215611_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221878_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221558_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221558_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563594_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221565_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221560_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221560_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221878_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221562_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221563_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221563_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221565_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221910_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221571_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221571_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563369_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221578_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221573_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221573_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221910_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221575_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221576_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221576_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221578_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563596_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221724_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221724_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2516596_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563369_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221724_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2224273_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2517599_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2227382_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227369_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227369_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227560_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227553_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227556_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227560_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227553_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2503967_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2229124_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2229124_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2229131_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234930_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2234927_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2234939_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234936_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234948_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234945_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2392865_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2393016_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2454052_0 | SINK | 3600.001.04 Tilluft: 8
InPort_2491820_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491833_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2491829_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491820_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2491831_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491822_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2491823_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492043_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492048_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491823_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492041_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491825_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2491825_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491829_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2491833_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2491831_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492043_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492041_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570029_6 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492048_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492089_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492119_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495256_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492089_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492091_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492104_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492117_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492091_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492111_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492093_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492093_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492108_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492097_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492111_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492113_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492097_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492097_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562830_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492106_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492101_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492102_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492113_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492104_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492102_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492108_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492106_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492115_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492117_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492119_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2492115_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2492491_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492502_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492506_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492492_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492492_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492531_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492496_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492494_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492494_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492510_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492510_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492497_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492497_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492534_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492499_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492504_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492537_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492500_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492500_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563003_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492502_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492506_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492504_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492508_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492508_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492535_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492512_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492515_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492540_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492513_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492513_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562999_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492515_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492517_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492517_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492538_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492519_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492522_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492528_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492520_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492520_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493138_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492522_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492524_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492524_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492526_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492526_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492528_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492531_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492529_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492529_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493223_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492534_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492532_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492532_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493297_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492535_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492537_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492538_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492540_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492541_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492544_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492550_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492542_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492542_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493085_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492544_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492546_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492546_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492548_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492548_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492550_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492551_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492554_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492560_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492552_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492552_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493170_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492554_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492556_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492556_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492558_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492558_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492560_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492561_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492564_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492570_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492562_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492562_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493265_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492564_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492566_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492566_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492568_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492568_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492570_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492571_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492574_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492580_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492572_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492572_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2493329_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492574_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492576_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492576_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492578_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492578_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492580_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492581_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492584_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492590_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492582_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492582_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563001_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492584_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492586_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492586_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492588_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2492588_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2492590_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2493612_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493606_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493606_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493623_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493610_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493612_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493634_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493610_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493621_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493616_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493632_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493617_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493617_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493634_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493619_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493626_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496041_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493619_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493623_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493621_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493626_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493624_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493624_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493630_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493630_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493628_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493628_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493632_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493809_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493818_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493814_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493809_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493816_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493811_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493821_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493812_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493812_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493814_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493818_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493816_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493819_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493821_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493881_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493819_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2493823_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493881_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570063_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2493823_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570045_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495253_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495253_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495256_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495795_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495791_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495791_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495804_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495793_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495795_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495815_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495793_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495802_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495797_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495813_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495798_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495798_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495815_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496085_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495800_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495800_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495807_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495804_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495802_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495807_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495805_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495805_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495811_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495811_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495809_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495809_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495813_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495863_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495859_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495859_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495872_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495861_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495863_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495883_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495861_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495870_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495865_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495881_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495866_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495866_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495883_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496129_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495868_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495868_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495875_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495872_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495870_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495875_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495873_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495873_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495879_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495879_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495877_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495877_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495881_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495929_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495925_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495925_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495938_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495927_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495929_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495949_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495927_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495936_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495931_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495947_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495932_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495932_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495949_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496173_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495934_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495934_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495941_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495938_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495936_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495941_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495939_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495939_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495945_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495945_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495943_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2495943_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2495947_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570041_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496038_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496038_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496041_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570037_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496082_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496082_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496085_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570033_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496126_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496126_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496129_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570061_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496170_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496170_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496173_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496216_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496240_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496622_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496216_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496218_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496231_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496238_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496218_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496224_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496220_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496220_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496235_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496222_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496224_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496229_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496222_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496233_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496226_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496227_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496229_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496231_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496227_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496235_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496233_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496236_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496238_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496240_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496236_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570065_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496619_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2496619_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2496622_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517669_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2502618_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2502618_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562022_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2515416_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2503967_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528707_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2514649_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2514649_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2514739_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2514739_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2514733_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2514733_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2514840_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2514835_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2514838_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2514840_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2514835_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2514838_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2516763_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2515247_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562974_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2517868_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2515416_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2516601_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2516427_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2516596_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2516593_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2516593_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2516601_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2516763_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2516977_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517013_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2516886_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2516886_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517758_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2516886_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517673_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2516977_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2516989_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2516989_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517013_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517599_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2517596_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2517596_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2517603_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2517673_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517666_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517666_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517669_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517749_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517752_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517756_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517749_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517752_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517865_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517758_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517756_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2517865_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2517868_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2518057_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2518051_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2518051_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2518061_2 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2518065_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2518054_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2518054_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2518057_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2529049_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528707_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528975_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528969_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528969_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528979_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528986_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528972_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528972_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528975_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528986_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528983_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528983_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529052_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529041_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529035_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529035_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529045_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529052_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529038_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529038_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529041_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529052_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529049_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562020_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562018_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562022_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562020_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562757_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562824_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562830_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562757_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562761_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562759_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562759_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562766_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562762_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562761_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562824_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562762_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562974_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563007_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562999_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562974_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563001_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562974_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563003_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562974_9 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563005_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562974_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563371_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563120_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563120_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563178_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563174_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563120_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563176_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563120_5 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563359_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563371_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563592_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563485_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563485_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563596_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2563594_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2563485_3 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2570029_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570094_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570029_7 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570033_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570029_8 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570037_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570029_9 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570041_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570029_10 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570045_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570143_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570089_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570156_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570143_1 | SOURCE | 3600.001.05 Avtrekk: 7
OutPort_2587792_0 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2600625_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 20

# IfcFlowFitting: Lindab ESU:ESU (2)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: ESU; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (Lindab ESU:ESU:...)
2209196
2209198

# IfcFlowFitting: Lindab TCPU:TCPU (2)
In: 0-Havnivå
Type - Description: T-stykke, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: TCPU; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Lindab TCPU:TCPU:...)
2528986
2529052

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (53)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2229131 | 3600.001.05 Avtrekk: 7
2491829 | 3600.001.05 Avtrekk: 7
2492041 | 3600.001.05 Avtrekk: 7
2492104 | 3600.001.05 Avtrekk: 7
2492111 | 3600.001.05 Avtrekk: 7
2492113 | 3600.001.05 Avtrekk: 7
2492117 | 3600.001.05 Avtrekk: 7
2492119 | 3600.001.05 Avtrekk: 7
2493612 | 3600.001.05 Avtrekk: 7
2493626 | 3600.001.05 Avtrekk: 7
2493630 | 3600.001.05 Avtrekk: 7
2493632 | 3600.001.05 Avtrekk: 7
2493634 | 3600.001.05 Avtrekk: 7
2493814 | 3600.001.05 Avtrekk: 7
2493821 | 3600.001.05 Avtrekk: 7
2493881 | 3600.001.05 Avtrekk: 7
2495256 | 3600.001.05 Avtrekk: 7
2495795 | 3600.001.05 Avtrekk: 7
2495807 | 3600.001.05 Avtrekk: 7
2495811 | 3600.001.05 Avtrekk: 7
2495813 | 3600.001.05 Avtrekk: 7
2495815 | 3600.001.05 Avtrekk: 7
2495863 | 3600.001.05 Avtrekk: 7
2495875 | 3600.001.05 Avtrekk: 7
2495879 | 3600.001.05 Avtrekk: 7
2495881 | 3600.001.05 Avtrekk: 7
2495883 | 3600.001.05 Avtrekk: 7
2495929 | 3600.001.05 Avtrekk: 7
2495941 | 3600.001.05 Avtrekk: 7
2495945 | 3600.001.05 Avtrekk: 7
2495947 | 3600.001.05 Avtrekk: 7
2495949 | 3600.001.05 Avtrekk: 7
2496041 | 3600.001.05 Avtrekk: 7
2496085 | 3600.001.05 Avtrekk: 7
2496129 | 3600.001.05 Avtrekk: 7
2496173 | 3600.001.05 Avtrekk: 7
2496224 | 3600.001.05 Avtrekk: 7
2496229 | 3600.001.05 Avtrekk: 7
2496231 | 3600.001.05 Avtrekk: 7
2496238 | 3600.001.05 Avtrekk: 7
2496240 | 3600.001.05 Avtrekk: 7
2496622 | 3600.001.05 Avtrekk: 7
2503967 | 3600.001.05 Avtrekk: 7
2514838 | 3600.001.05 Avtrekk: 7
2516596 | 3600.001.04 Tilluft: 8
2517599 | 3600.001.04 Tilluft: 8
2517669 | 3600.001.05 Avtrekk: 7
2517752 | 3600.001.05 Avtrekk: 7
2517756 | 3600.001.05 Avtrekk: 7
2528673 | 3600.001.05 Avtrekk: 7
2562018 | 3600.001.05 Avtrekk: 7
2562824 | 3600.001.05 Avtrekk: 7
2570089 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (16)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2213128 | 3600.001.08 Spesialavtrekk: 20
2227556 | 3600.001.08 Spesialavtrekk: 20
2227560 | 3600.001.08 Spesialavtrekk: 20
2513505 | 3600.001.08 Spesialavtrekk: 20
2513677 | 3600.001.08 Spesialavtrekk: 20
2514739 | 3600.001.05 Avtrekk: 7
2514840 | 3600.001.05 Avtrekk: 7
2516977 | 3600.001.05 Avtrekk: 7
2517013 | 3600.001.05 Avtrekk: 7
2518057 | 3600.001.08 Spesialavtrekk: 20
2518061 | 3600.001.08 Spesialavtrekk: 20
2528707 | 3600.001.05 Avtrekk: 7
2528975 | 3600.001.05 Avtrekk: 7
2528979 | 3600.001.05 Avtrekk: 7
2529041 | 3600.001.05 Avtrekk: 7
2529045 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (3)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...)
2515252
2516601
2517603

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv (22)
In: 0-Havnivå
Type - Description: Bend, Sirkulær Galv; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001 Galv; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv:...)
2209077
2209081
2209085
2209089
2209126
2209181
2209187
2209189
2209303
2221878
2221910
2492506
2492508
2492510
2492517
2492524
2492546
2492556
2492566
2492576
2492586
2515247

# IfcFlowFitting: magicirc_elbow_short_1:magicirc_elbow_short_001 (2)
In: 0-Havnivå
Type - Description: Circular,smooth, minimum radius; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_short_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (magicirc_elbow_short_1:magicirc_elbow_short_001:...)
2513444
2513509

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001 (3)
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (magicirc_plug_001:magicirc_plug_001:...) | In
2166584 | PLAN +10,50
2393016 | 0-Havnivå
2496204 | 0-Havnivå

# IfcFlowFitting: magicirc_reduction_001:magicirc_reduction_001 (9)
In: 0-Havnivå
Type - Description: Overgang, Sirkulær; Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_001; sets with these values: 2
Name (magicirc_reduction_001:magicirc_reduction_001:...) | Group
2492043 | 3600.001.05 Avtrekk: 7
2517758 | 3600.001.05 Avtrekk: 7
2563007 | 3600.001.04 Tilluft: 8
2563178 | 3600.001.04 Tilluft: 8
2563371 | 3600.001.04 Tilluft: 8
2563592 | 3600.001.04 Tilluft: 8
2563596 | 3600.001.04 Tilluft: 8
2570094 | 3600.001.05 Avtrekk: 7
2570156 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (10)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2492048
2517673
2562830
2570033
2570037
2570041
2570045
2570061
2570063
2570065

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (11)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2209005
2209007
2209009
2209011
2209021
2209059
2209061
2209063
2227382
2513450
2518065

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (18)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2215562
2215566
2215570
2493085
2493138
2493170
2493223
2493265
2493297
2493329
2562999
2563001
2563003
2563005
2563174
2563176
2563369
2563594

# IfcFlowSegment: Round Duct:Sirkulær kanal Galv (70)
In: 0-Havnivå
Type - Description: Sirkulær kanal, Galvanisert stål; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal Galv; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (Round Duct:Sirkulær kanal Galv:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm)
2208979 | 6759.86
2209035 | 65.0097
2209037 | 540.302
2209040 | 65.0097
2209042 | 478.893
2209045 | 65.0097
2209047 | 481.243
2209050 | 150.008
2209052 | 595.771
2209065 | 472.229
2209068 | 566.757
2209071 | 469.107
2209074 | 467.698
2209118 | 150.008
2209120 | 481.243
2209123 | 586.757
2209166 | 34221
2209172 | 4306.35
2209174 | 490.764
2209183 | 23120
2209192 | 519
2209301 | 3488.88
2211125 | 46213.1
2215611 | 986.437
2221558 | 487.495
2221560 | 474.226
2221563 | 444.512
2221571 | 437.495
2221573 | 474.914
2221576 | 458.455
2221724 | 2737.72
2224273 | 21195.5
2454052 | 794
2492492 | 300.92
2492494 | 1600.7
2492497 | 300.918
2492500 | 401.603
2492502 | 1000.7
2492504 | 1600.71
2492513 | 401.605
2492515 | 1600.71
2492520 | 301.597
2492522 | 1000.71
2492526 | 300.922
2492529 | 301.599
2492532 | 301.601
2492535 | 300.916
2492538 | 300.914
2492542 | 301.596
2492544 | 1000.71
2492548 | 300.923
2492552 | 301.598
2492554 | 1000.71
2492558 | 300.921
2492562 | 301.6
2492564 | 1600.71
2492568 | 300.919
2492572 | 301.602
2492574 | 1600.71
2492578 | 300.917
2492582 | 401.604
2492584 | 1600.71
2492588 | 300.915
2516427 | 957.937
2516593 | 536.941
2517596 | 848.361
2562974 | 24006
2563120 | 26419
2563359 | 5487
2563485 | 6217

# IfcFlowSegment: Round Duct:Sirkulær kanal PVC (14)
In: 0-Havnivå
Type - Description: Sirkulær kanal, PVC; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal PVC; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal PVC:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2209099 | 2439.74 | 3600.001.08 Spesialavtrekk: 20
2209107 | 901.779 | 3600.001.05 Avtrekk: 7
2209111 | 799.709 | 3600.001.05 Avtrekk: 7
2209217 | 2166.25 | 3600.001.05 Avtrekk: 7
2209235 | 3279.89 | 3600.001.05 Avtrekk: 7
2234927 | 1209.36 | 3600.001.08 Spesialavtrekk: 20
2234936 | 1255.27 | 3600.001.05 Avtrekk: 7
2234945 | 1415.9 | 3600.001.05 Avtrekk: 7
2528969 | 536.414 | 3600.001.05 Avtrekk: 7
2528972 | 98.5625 | 3600.001.05 Avtrekk: 7
2529035 | 536.414 | 3600.001.05 Avtrekk: 7
2529038 | 157.127 | 3600.001.05 Avtrekk: 7
2562759 | 1020 | 3600.001.05 Avtrekk: 7
2562762 | 1232.67 | 3600.001.05 Avtrekk: 7

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (109)
In: 0-Havnivå
Type - Description: Sirkulær kanal syrefast; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal SF 1; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2166577 | 26680 | 3600.001.08 Spesialavtrekk: 20
2166579 | 3562.87 | 3600.001.08 Spesialavtrekk: 20
2166596 | 1947.48 | 3600.001.08 Spesialavtrekk: 20
2208975 | 6901.95 | 3600.001.05 Avtrekk: 7
2208977 | 42573 | 3600.001.05 Avtrekk: 7
2208987 | 39388.8 | 3600.001.08 Spesialavtrekk: 20
2208993 | 817.187 | 3600.001.08 Spesialavtrekk: 20
2208995 | 852.056 | 3600.001.08 Spesialavtrekk: 20
2208997 | 980.845 | 3600.001.08 Spesialavtrekk: 20
2208999 | 945.72 | 3600.001.08 Spesialavtrekk: 20
2209013 | 884.278 | 3600.001.08 Spesialavtrekk: 20
2209015 | 930.73 | 3600.001.08 Spesialavtrekk: 20
2209017 | 822.343 | 3600.001.08 Spesialavtrekk: 20
2209019 | 1023.63 | 3600.001.08 Spesialavtrekk: 20
2209029 | 27539 | 3600.001.08 Spesialavtrekk: 20
2209030 | 688.799 | 3600.001.08 Spesialavtrekk: 20
2209093 | 3336.98 | 3600.001.08 Spesialavtrekk: 20
2209179 | 4104.38 | 3600.001.04 Tilluft: 8
2209244 | 642.657 | 3600.001.08 Spesialavtrekk: 20
2209247 | 441.366 | 3600.001.08 Spesialavtrekk: 20
2209250 | 534.27 | 3600.001.08 Spesialavtrekk: 20
2209253 | 580.722 | 3600.001.08 Spesialavtrekk: 20
2209256 | 529.608 | 3600.001.08 Spesialavtrekk: 20
2209259 | 494.484 | 3600.001.08 Spesialavtrekk: 20
2209262 | 623.272 | 3600.001.08 Spesialavtrekk: 20
