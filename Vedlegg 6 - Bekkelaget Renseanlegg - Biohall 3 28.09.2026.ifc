Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (95)
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2204041 | 1430.86 | 3600.001.05 Avtrekk: 7
2204045 | 3220 | 3600.001.05 Avtrekk: 7
2204049 | 7128.04 | 3600.001.05 Avtrekk: 7
2204057 | 1810.49 | 3600.001.08 Spesialavtrekk: 21
2204059 | 34902.3 | 3600.001.08 Spesialavtrekk: 21
2204061 | 3315.35 | 3600.001.08 Spesialavtrekk: 21
2204063 | 42111.7 | 3600.001.08 Spesialavtrekk: 21
2204069 | 817.187 | 3600.001.08 Spesialavtrekk: 21
2204071 | 852.056 | 3600.001.08 Spesialavtrekk: 21
2204073 | 980.845 | 3600.001.08 Spesialavtrekk: 21
2204075 | 945.72 | 3600.001.08 Spesialavtrekk: 21
2204077 | 71068 | 3600.001.08 Spesialavtrekk: 21
2204089 | 878.908 | 3600.001.08 Spesialavtrekk: 21
2204091 | 925.36 | 3600.001.08 Spesialavtrekk: 21
2204093 | 816.972 | 3600.001.08 Spesialavtrekk: 21
2204095 | 1018.26 | 3600.001.08 Spesialavtrekk: 21
2204099 | 4006.87 | 3600.001.05 Avtrekk: 7
2204101 | 4765.37 | 3600.001.05 Avtrekk: 7
2204109 | 5755.14 | 3600.001.05 Avtrekk: 7
2204111 | 2258.12 | 3600.001.05 Avtrekk: 7
2204119 | 2445.5 | 3600.001.05 Avtrekk: 7
2204121 | 1893.37 | 3600.001.05 Avtrekk: 7
2204123 | 1286.59 | 3600.001.05 Avtrekk: 7
2204129 | 2638.16 | 3600.001.05 Avtrekk: 7
2204141 | 28434.8 | 3600.001.08 Spesialavtrekk: 21
2204142 | 687.834 | 3600.001.08 Spesialavtrekk: 21
2204292 | 614.315 | 3600.001.08 Spesialavtrekk: 21
2204375 | 180.352 | 3600.001.05 Avtrekk: 7
2204427 | 2837.87 | 3600.001.05 Avtrekk: 7
2204429 | 2109.52 | 3600.001.05 Avtrekk: 7
2204431 | 1258.83 | 3600.001.05 Avtrekk: 7
2204437 | 2973.13 | 3600.001.05 Avtrekk: 7
2204444 | 117.133 | 3600.001.05 Avtrekk: 7
2204539 | 471.381 | 3600.001.05 Avtrekk: 7
2204543 | 372.165 | 3600.001.05 Avtrekk: 7
2204552 | 1490.66 | 3600.001.05 Avtrekk: 7
2204554 | 3274.08 | 3600.001.05 Avtrekk: 7
2204556 | 2253.54 | 3600.001.05 Avtrekk: 7
2204616 | 3640.24 | 3600.001.08 Spesialavtrekk: 21
2204624 | 2101.45 | 3600.001.08 Spesialavtrekk: 21
2204746 | 642.657 | 3600.001.08 Spesialavtrekk: 21
2204749 | 441.366 | 3600.001.08 Spesialavtrekk: 21
2204752 | 534.27 | 3600.001.08 Spesialavtrekk: 21
2204755 | 580.722 | 3600.001.08 Spesialavtrekk: 21
2204758 | 529.608 | 3600.001.08 Spesialavtrekk: 21
2204761 | 494.484 | 3600.001.08 Spesialavtrekk: 21
2204764 | 623.272 | 3600.001.08 Spesialavtrekk: 21
2204767 | 658.141 | 3600.001.08 Spesialavtrekk: 21
2204770 | 1193.61 | 3600.001.05 Avtrekk: 7
2204773 | 1193.61 | 3600.001.05 Avtrekk: 7
2204791 | 993.589 | 3600.001.05 Avtrekk: 7
2204794 | 984.589 | 3600.001.05 Avtrekk: 7
2204797 | 984.589 | 3600.001.05 Avtrekk: 7
2204800 | 922.5 | 3600.001.08 Spesialavtrekk: 21
2229300 | 24589.8 | 3600.001.05 Avtrekk: 7
2504809 | 471.381 | 3600.001.05 Avtrekk: 7
2504811 | 372.165 | 3600.001.05 Avtrekk: 7
2504818 | 1490.66 | 3600.001.05 Avtrekk: 7
2504820 | 3274.08 | 3600.001.05 Avtrekk: 7
2504822 | 2253.54 | 3600.001.05 Avtrekk: 7
2504826 | 993.589 | 3600.001.05 Avtrekk: 7
2504857 | 471.381 | 3600.001.05 Avtrekk: 7
2504859 | 372.165 | 3600.001.05 Avtrekk: 7
2504866 | 1490.66 | 3600.001.05 Avtrekk: 7
2504868 | 3274.08 | 3600.001.05 Avtrekk: 7
2504870 | 2253.54 | 3600.001.05 Avtrekk: 7
2504874 | 993.589 | 3600.001.05 Avtrekk: 7
2504958 | 471.381 | 3600.001.05 Avtrekk: 7
2504960 | 372.165 | 3600.001.05 Avtrekk: 7
2504967 | 1490.66 | 3600.001.05 Avtrekk: 7
2504969 | 3374.08 | 3600.001.05 Avtrekk: 7
2504971 | 2253.54 | 3600.001.05 Avtrekk: 7
2504975 | 993.589 | 3600.001.05 Avtrekk: 7
2505525 | 3410.64 | 3600.001.05 Avtrekk: 7
2505653 | 61.8559 | 3600.001.05 Avtrekk: 7
2506292 | 260.998 | 3600.001.05 Avtrekk: 7
2506505 | 4001.03 | 3600.001.05 Avtrekk: 7
2507260 | 108.9 | 3600.001.08 Spesialavtrekk: 21
2508405 | 230.928 | 3600.001.08 Spesialavtrekk: 21
2508548 | 3913.8 | 3600.001.08 Spesialavtrekk: 21
2521221 | 43273 | 3600.001.05 Avtrekk: 7
2521693 | 991.062 | 3600.001.08 Spesialavtrekk: 21
2522141 | 4856.27 | 3600.001.05 Avtrekk: 7
2522499 | 592.709 | 3600.001.05 Avtrekk: 7
2522633 | 14892.1 | 3600.001.05 Avtrekk: 7
2522836 | 1100 | 3600.001.05 Avtrekk: 7
2523124 | 995.277 | 3600.001.05 Avtrekk: 7
2523167 | 454.742 | 3600.001.05 Avtrekk: 7
2528414 | 17702.5 | 3600.001.05 Avtrekk: 7
2528544 | 823.769 | 3600.001.05 Avtrekk: 7
2570307 | 46309.1 | 3600.001.05 Avtrekk: 7
2570461 | 19274.5 | 3600.001.05 Avtrekk: 7
2572051 | 484.918 | 3600.001.05 Avtrekk: 7
2587783 | 790 | 3600.001.05 Avtrekk: 7

# IfcFlowTerminal: Netting-A:Netting-A-250 2, Netting-A:Netting-A-250 2:2571734
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-250 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowTerminal: Netting-A:Netting-A-315 2 (4)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-315 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-315 2:...)
2204549
2504815
2504863
2504964

# IfcFlowTerminal: Netting-A:Netting-A-400 2 (3)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-400 2; sets with these values: 2
Name (Netting-A:Netting-A-400 2:...) | Group
2204314 | 3600.001.05 Avtrekk: 7
2204315 | 3600.001.05 Avtrekk: 7
2204316 | 3600.001.08 Spesialavtrekk: 21

# IfcFlowTerminal: Netting-A:Netting-A-500 2 (6)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-500 2:...)
2204043
2204044
2204173
2204443
2204696
2204714

# IfcFlowTerminal: SI-T_V:SI-T/V-1212 (11)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1212; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1212:...)
2204159
2204166
2204178
2204183
2204188
2204193
2204218
2204325
2204482
2204498
2204514

# IfcFlowTerminal: SI-T_V:SI-T/V-1218 (6)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1218; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1218:...)
2204150
2204229
2204450
2204466
2221950
2221964

# IfcFlowTerminal: UPK-H-K-B-400:UPK-H-K-B-400 (8)
In: 0-Havnivå
Type - Description: Exhaust diffusor; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: UPK-H-K-B-400; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 21
Name (UPK-H-K-B-400:UPK-H-K-B-400:...)
2204137
2204138
2204139
2204140
2204194
2204195
2204196
2204197
