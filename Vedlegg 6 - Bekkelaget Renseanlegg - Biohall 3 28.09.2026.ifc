Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c04e82b7-d741-4bb0-b665-850c62e824b8, VersionGUID: 0e62efc3-157c-450f-8d85-b250ddbc97cd, NumberOfSaves: 1595], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Bekkelaget Renseanlegg - Biohall 3.ifc
Time: 2026-07-02T14:15:19+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENU) - 26.4.10.8

# IfcProject, 52502296
LongName: Bekkelaget RA - Oppgradering 2000-anlegget; Phase: ---

# IfcSite, Default
RefLatitude: 49, 0, 24, 428900; RefLongitude: 9, 7, 59, 338362; RefElevation: 0 mm

# IfcBuilding, Bygning (endres i Project Information)
LongName: Bygning (endres i Project Information)
Pset_BuildingCommon - NumberOfStoreys: 11

# IfcBuildingStorey (11)
In: Bygning (endres i Project Information)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
+00,00 | +00,00 | -8.84387e-11
Plan 01 | Plan 01 | 0
0-Havnivå | 0-Havnivå | 0
PLAN +2,50 | PLAN +2,50 | 2500
Plan 02 | Plan 02 | 3500
PLAN +5,00 | PLAN +5,00 | 5000
Plan 03 | Plan 03 | 7000
PLAN +7,80 | PLAN +7,80 | 7800
PLAN +10,50 | PLAN +10,50 | 10500
PLAN +13,40 | PLAN +13,40 | 13400
PLAN +16,00 | PLAN +16,00 | 16000

# IfcBuildingElementProxy: DRU:DRU 250, DRU:DRU 250:2571731
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 250; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: DRU:DRU 400 (11)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 400; sets with these values: 2
Name (DRU:DRU 400:...) | Group
2204748 | 3600.001.08 Spesialavtrekk: 21
2204751 | 3600.001.08 Spesialavtrekk: 21
2204754 | 3600.001.08 Spesialavtrekk: 21
2204757 | 3600.001.08 Spesialavtrekk: 21
2204760 | 3600.001.08 Spesialavtrekk: 21
2204763 | 3600.001.08 Spesialavtrekk: 21
2204766 | 3600.001.08 Spesialavtrekk: 21
2204769 | 3600.001.08 Spesialavtrekk: 21
2234513 | 3600.001.05 Avtrekk: 7
2234522 | 3600.001.05 Avtrekk: 7
2234531 | 3600.001.08 Spesialavtrekk: 21

# IfcBuildingElementProxy: IRIS:IRIS-315 2 (23)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-315 2; sets with these values: 2
Name (IRIS:IRIS-315 2:...) | Group
2204244 | 3600.001.04 Tilluft: 8
2204247 | 3600.001.04 Tilluft: 8
2204250 | 3600.001.04 Tilluft: 8
2204253 | 3600.001.04 Tilluft: 8
2204256 | 3600.001.04 Tilluft: 8
2204260 | 3600.001.04 Tilluft: 8
2204263 | 3600.001.04 Tilluft: 8
2204266 | 3600.001.04 Tilluft: 8
2204269 | 3600.001.04 Tilluft: 8
2204328 | 3600.001.04 Tilluft: 8
2204465 | 3600.001.04 Tilluft: 8
2204481 | 3600.001.04 Tilluft: 8
2204497 | 3600.001.04 Tilluft: 8
2204513 | 3600.001.04 Tilluft: 8
2204529 | 3600.001.04 Tilluft: 8
2204672 | 3600.001.04 Tilluft: 8
2204675 | 3600.001.04 Tilluft: 8
2204793 | 3600.001.05 Avtrekk: 7
2221953 | 3600.001.04 Tilluft: 8
2221967 | 3600.001.04 Tilluft: 8
2504828 | 3600.001.05 Avtrekk: 7
2504876 | 3600.001.05 Avtrekk: 7
2504977 | 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: IRIS:IRIS-500 2 (6)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: IRIS-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (IRIS:IRIS-500 2:...)
2204772
2204775
2204796
2204799
2523170
2562070

# IfcBuildingElementProxy: LKR-1200:LKR-800-1200, LKR-1200:LKR-800-1200:2204806
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: LKR-800-1200; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 21

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500, LKR-1500:LKR-1000-1500:2204829
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500, LKR-1500:LKR-1000-1500:2204149
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: Toposolid:Toposolid 1, Toposolid:Toposolid 1:2375720
In: Plan 01
Material: Glass
Pset_BuildingElementProxyCommon - Reference: Toposolid 1; sets with these values: 2
Pset_ProductRequirements - Name: Terrengmodell - Biohall 1 5

# IfcDistributionPort (861)
Description: Flow
Name | FlowDirection | Group
InPort_2204039_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204799_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204319_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204039_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204041_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204796_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204317_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204041_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204797_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204043_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204794_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204044_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570587_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204045_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204045_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522024_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522024_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204049_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204049_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528295_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2564811_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204053_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204149_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204507_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204491_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_5 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204475_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_6 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204459_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204208_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204210_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_11 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204238_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204053_12 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204055_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2519751_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2519755_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204055_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2508649_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204057_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204057_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2508653_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204059_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2213298_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2230743_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204059_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204059_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204097_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204059_3 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204198_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204059_4 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204200_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204059_5 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204202_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204061_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2507296_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2507302_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204061_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204063_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204135_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2507265_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204063_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204063_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204081_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204063_3 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204083_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204063_4 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204085_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204063_5 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204087_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204069_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204769_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204081_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204069_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204071_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204766_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204083_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204071_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204073_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204763_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204085_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204073_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204087_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204075_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204075_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204760_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204806_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204077_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204077_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204636_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204077_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2507302_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204077_3 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2508412_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204089_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204757_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204097_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204089_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204091_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204754_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204202_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204091_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204093_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204748_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204200_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204093_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204095_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204751_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204198_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204095_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204099_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506826_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570392_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204099_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506826_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204101_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204101_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204319_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204109_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2505344_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562029_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204109_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572054_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204111_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204111_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204317_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506295_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204119_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204119_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506517_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204121_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506653_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506657_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204121_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204131_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204123_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204123_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204775_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204129_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204131_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204377_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204129_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204767_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204137_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204764_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204138_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204761_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204139_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204758_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204140_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204145_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204141_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204141_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204680_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204141_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2521628_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204142_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204145_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2213298_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204142_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204147_0 | SINK | 3600.001.04 Tilluft: 8
InPort_2204149_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204147_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204150_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204204_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204212_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204151_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204151_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204247_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204155_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204153_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204153_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204210_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204245_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204155_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204159_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204157_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204157_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204216_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204216_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204160_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204160_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204250_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204164_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204162_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204162_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204208_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204248_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204164_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204166_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204206_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204253_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204167_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204167_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204171_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204171_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204169_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204169_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564805_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204773_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204173_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204284_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204174_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204174_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215642_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204178_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204176_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204176_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204269_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204280_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204179_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204179_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215644_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204266_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204181_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204181_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204280_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204183_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204264_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204276_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204184_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204184_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215646_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204263_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204186_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204186_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204276_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204188_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204261_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204272_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204189_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204189_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566930_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204193_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204191_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204191_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204260_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204755_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204194_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204752_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204195_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204749_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204196_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204746_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204197_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204204_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204212_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204206_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204214_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204214_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204251_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204218_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204225_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204256_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204219_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204219_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204223_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204223_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204221_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204221_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564807_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204225_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204227_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204227_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204254_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204229_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204236_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204244_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204230_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204230_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204234_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204234_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204232_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204232_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204238_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204236_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204240_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204240_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204242_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204242_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204244_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204247_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204245_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204250_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204248_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204251_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204253_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204254_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204256_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204260_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204258_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204258_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204272_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204261_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204263_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204264_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204266_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204269_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204267_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204267_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204284_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2521628_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204292_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204292_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2521696_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204298_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2234531_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2521700_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204298_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2528540_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204306_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204306_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234522_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204310_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234513_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528410_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204310_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234519_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204314_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234510_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204315_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234528_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204316_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204329_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204321_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204321_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566932_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204328_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204323_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204323_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204329_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204325_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204326_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204326_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204328_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204375_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204377_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506653_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204375_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2505656_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204427_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204427_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506062_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204429_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204448_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506066_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204429_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204439_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204431_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204431_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204772_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204437_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204439_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204446_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204437_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204770_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204443_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204444_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204446_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204448_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204444_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204450_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204457_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204465_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204451_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204451_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204455_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204455_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204453_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204453_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204459_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204457_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204461_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204461_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204463_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204463_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204465_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204466_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204473_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204481_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204467_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204467_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204471_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204471_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204469_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204469_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204475_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204473_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204477_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204477_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204479_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204479_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204481_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204482_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204489_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204497_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204483_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204483_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204487_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204487_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204485_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204485_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204491_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204489_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204493_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204493_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204495_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204495_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204497_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204498_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204505_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204513_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204499_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204499_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204503_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204503_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204501_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204501_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204507_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204505_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204509_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204509_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204511_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204511_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204513_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204514_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204521_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204529_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204515_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204515_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204519_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204519_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204517_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204517_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564809_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204521_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204525_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204525_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204527_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204527_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204529_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204545_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204539_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204539_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204793_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204543_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204545_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204550_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204543_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204791_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204549_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204552_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204550_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204558_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204552_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204554_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504772_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504777_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204554_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204556_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204558_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504770_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204556_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2507296_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204616_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204616_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2507263_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204624_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2230743_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2508563_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204624_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2566934_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204642_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204642_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2519755_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215642_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204642_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215644_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204642_9 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215646_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204642_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204648_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2507541_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2507686_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204648_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204661_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204672_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204676_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204661_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204663_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518811_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204678_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204663_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204672_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204670_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204670_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2508281_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204675_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2205721_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2224507_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2204675_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2204697_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204696_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2523424_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204697_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204715_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204714_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562066_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204715_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204748_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204746_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204751_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204749_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204754_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204752_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204757_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204755_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204760_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204758_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204763_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204761_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204766_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204764_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204769_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204767_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2204772_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204770_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204775_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204773_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204793_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204791_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204796_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204794_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204799_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204797_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204800_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2204806_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
OutPort_2204800_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2587783_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2204829_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2204829_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570307_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2205610_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518849_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2205742_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2205610_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2205721_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567618_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567537_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2205742_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2569831_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221946_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221946_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2569837_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221953_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221948_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221948_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2569831_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221950_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221951_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221951_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221953_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2569800_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221960_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221960_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2569806_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221967_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221962_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221962_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2569800_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221964_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221965_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221965_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221967_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2222357_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567607_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567618_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222357_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2569806_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2222357_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518815_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2224507_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2229300_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523424_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2523127_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2229300_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234513_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234510_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234522_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2234519_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2234531_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2234528_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2504772_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504770_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570307_6 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504777_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504813_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504809_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504809_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504828_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504811_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504813_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504816_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504811_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504826_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504815_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504818_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504816_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504824_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504818_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504820_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504831_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504833_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504820_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504822_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504824_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504829_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504822_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504828_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504826_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504831_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504829_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570307_5 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504833_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504861_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504857_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504857_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504876_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504859_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504861_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504864_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504859_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504874_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504863_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504866_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504864_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504872_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504866_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504868_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504879_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504881_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504868_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504870_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504872_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504877_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504870_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504876_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504874_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504879_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504877_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570307_4 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504881_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504962_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504958_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504958_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504977_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504960_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504962_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504965_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504960_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504975_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504964_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504967_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504965_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504973_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504967_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504969_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504980_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570390_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504969_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504971_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504973_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504978_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504971_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504977_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504975_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2504980_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2504978_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2505344_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572051_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506062_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2505525_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2505525_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506066_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570312_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2505653_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2505653_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2505656_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570466_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506292_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506292_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506295_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506517_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506505_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2506505_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2506657_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2507263_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2507260_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2507260_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2507265_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2507538_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564803_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2507541_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2507538_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2507702_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2507686_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2508277_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2507702_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2508274_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2508277_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2508281_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2508274_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2508412_2 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2508405_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2508405_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2508649_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2508548_0 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2508563_2 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2508653_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2508548_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2518811_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518808_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518808_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518815_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518835_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518838_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518849_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518835_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518838_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567144_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2519751_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564738_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2528295_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2521221_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2521221_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528417_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2521696_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2521693_0 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2521693_1 | SINK | 3600.001.08 Spesialavtrekk: 21
OutPort_2521700_1 | SOURCE | 3600.001.08 Spesialavtrekk: 21
InPort_2522506_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522141_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522141_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522641_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528482_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522499_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522499_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522506_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522641_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522633_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522633_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522839_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562070_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522829_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522829_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562066_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522839_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2522836_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522836_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523165_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522836_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523131_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2522839_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562068_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2523170_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523124_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2523124_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523127_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2523131_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523167_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2523167_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2523170_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528406_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528400_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528400_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528410_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528417_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528403_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528403_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528406_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528417_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528414_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528414_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528547_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528544_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528482_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528536_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528530_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528530_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528540_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528547_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528533_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528533_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528536_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2528547_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2528544_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570307_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562029_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562068_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562070_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2564738_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564811_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2564803_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564738_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2564805_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564738_11 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2564807_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564738_12 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2564809_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2564738_13 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567199_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566850_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566850_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566934_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566930_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566850_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2566932_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2566850_5 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567144_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567199_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2567607_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567537_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2569837_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2567537_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2570307_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570396_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570307_7 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570312_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570461_4 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570390_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570461_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570392_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570396_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570461_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570461_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570587_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2570461_5 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2570466_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571731_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571729_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571729_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571734_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571732_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571731_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572046_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571732_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572041_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572035_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572035_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572046_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572054_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572038_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572038_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572041_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2572051_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2572054_2 | SOURCE | 3600.001.05 Avtrekk: 7
OutPort_2587783_0 | SOURCE | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: Lindab ESU:ESU (2)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: ESU; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (Lindab ESU:ESU:...)
2204676
2204678

# IfcFlowFitting: Lindab TCPU:TCPU (4)
In: 0-Havnivå
Type - Description: T-stykke, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: TCPU; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Lindab TCPU:TCPU:...)
2522839
2528417
2528547
2572054

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (44)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2204131 | 3600.001.05 Avtrekk: 7
2204317 | 3600.001.05 Avtrekk: 7
2204319 | 3600.001.05 Avtrekk: 7
2204377 | 3600.001.05 Avtrekk: 7
2204439 | 3600.001.05 Avtrekk: 7
2204446 | 3600.001.05 Avtrekk: 7
2204448 | 3600.001.05 Avtrekk: 7
2204545 | 3600.001.05 Avtrekk: 7
2204550 | 3600.001.05 Avtrekk: 7
2204558 | 3600.001.05 Avtrekk: 7
2504770 | 3600.001.05 Avtrekk: 7
2504813 | 3600.001.05 Avtrekk: 7
2504816 | 3600.001.05 Avtrekk: 7
2504824 | 3600.001.05 Avtrekk: 7
2504829 | 3600.001.05 Avtrekk: 7
2504861 | 3600.001.05 Avtrekk: 7
2504864 | 3600.001.05 Avtrekk: 7
2504872 | 3600.001.05 Avtrekk: 7
2504877 | 3600.001.05 Avtrekk: 7
2504962 | 3600.001.05 Avtrekk: 7
2504965 | 3600.001.05 Avtrekk: 7
2504973 | 3600.001.05 Avtrekk: 7
2504978 | 3600.001.05 Avtrekk: 7
2505344 | 3600.001.05 Avtrekk: 7
2505656 | 3600.001.05 Avtrekk: 7
2506062 | 3600.001.05 Avtrekk: 7
2506066 | 3600.001.05 Avtrekk: 7
2506295 | 3600.001.05 Avtrekk: 7
2506517 | 3600.001.05 Avtrekk: 7
2506653 | 3600.001.05 Avtrekk: 7
2506657 | 3600.001.05 Avtrekk: 7
2506826 | 3600.001.05 Avtrekk: 7
2518815 | 3600.001.04 Tilluft: 8
2518849 | 3600.001.04 Tilluft: 8
2522024 | 3600.001.05 Avtrekk: 7
2523127 | 3600.001.05 Avtrekk: 7
2523424 | 3600.001.05 Avtrekk: 7
2528406 | 3600.001.05 Avtrekk: 7
2528410 | 3600.001.05 Avtrekk: 7
2528536 | 3600.001.05 Avtrekk: 7
2528540 | 3600.001.05 Avtrekk: 7
2562066 | 3600.001.05 Avtrekk: 7
2572041 | 3600.001.05 Avtrekk: 7
2572046 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (15)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2204145 | 3600.001.08 Spesialavtrekk: 21
2213298 | 3600.001.08 Spesialavtrekk: 21
2230743 | 3600.001.08 Spesialavtrekk: 21
2507263 | 3600.001.08 Spesialavtrekk: 21
2507265 | 3600.001.08 Spesialavtrekk: 21
2507296 | 3600.001.08 Spesialavtrekk: 21
2508563 | 3600.001.08 Spesialavtrekk: 21
2508649 | 3600.001.08 Spesialavtrekk: 21
2508653 | 3600.001.08 Spesialavtrekk: 21
2521696 | 3600.001.08 Spesialavtrekk: 21
2521700 | 3600.001.08 Spesialavtrekk: 21
2522506 | 3600.001.05 Avtrekk: 7
2522641 | 3600.001.05 Avtrekk: 7
2528295 | 3600.001.05 Avtrekk: 7
2528482 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (7)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...)
2507541
2507686
2508277
2508281
2518811
2518838
2519755

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv (29)
In: 0-Havnivå
Type - Description: Bend, Sirkulær Galv; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001 Galv; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv:...)
2204155
2204164
2204171
2204212
2204214
2204216
2204223
2204227
2204234
2204240
2204272
2204276
2204280
2204284
2204329
2204455
2204461
2204471
2204477
2204487
2204493
2204503
2204509
2204519
2204525
2205742
2519751
2569800
2569831

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001 (4)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Name (magicirc_plug_001:magicirc_plug_001:...) | Group
2204135 | 3600.001.08 Spesialavtrekk: 21
2204636 | 3600.001.08 Spesialavtrekk: 21
2204680 | 3600.001.08 Spesialavtrekk: 21
2523165 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_reduction_001:magicirc_reduction_001 (11)
In: 0-Havnivå
Type - Description: Overgang, Sirkulær; Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_001; sets with these values: 2
Name (magicirc_reduction_001:magicirc_reduction_001:...) | Group
2504772 | 3600.001.05 Avtrekk: 7
2504831 | 3600.001.05 Avtrekk: 7
2504879 | 3600.001.05 Avtrekk: 7
2504980 | 3600.001.05 Avtrekk: 7
2564811 | 3600.001.04 Tilluft: 8
2566934 | 3600.001.04 Tilluft: 8
2567199 | 3600.001.04 Tilluft: 8
2567607 | 3600.001.04 Tilluft: 8
2567618 | 3600.001.04 Tilluft: 8
2570396 | 3600.001.05 Avtrekk: 7
2570587 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (9)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2504777
2504833
2504881
2523131
2562029
2570312
2570390
2570392
2570466

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (11)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 21
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2204081
2204083
2204085
2204087
2204097
2204198
2204200
2204202
2507302
2508412
2521628

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (18)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2204208
2204210
2204238
2204459
2204475
2204491
2204507
2215642
2215644
2215646
2564803
2564805
2564807
2564809
2566930
2566932
2569806
2569837

# IfcFlowSegment: Round Duct:Sirkulær kanal Galv (82)
In: 0-Havnivå
Type - Description: Sirkulær kanal, Galvanisert stål; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal Galv; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (Round Duct:Sirkulær kanal Galv:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm)
2204053 | 46313.1
2204055 | 7030.17
2204147 | 794
2204151 | 481.414
2204153 | 824.659
2204157 | 1600.71
2204160 | 475.772
2204162 | 826.363
2204167 | 493.387
2204169 | 924.075
2204174 | 65.0473
2204176 | 660.302
2204179 | 65.0483
2204181 | 478.893
2204184 | 65.0492
2204186 | 481.243
2204189 | 150.066
2204191 | 475.771
2204204 | 1000.71
2204206 | 1600.71
2204219 | 444.018
2204221 | 927.706
2204225 | 1600.71
2204230 | 462.575
2204232 | 824.659
2204236 | 1000.71
2204242 | 460.923
2204245 | 442.084
2204248 | 446.202
2204251 | 431.847
2204254 | 477.494
2204258 | 472.229
2204261 | 546.757
2204264 | 569.107
2204267 | 467.698
2204321 | 150.066
2204323 | 481.243
2204326 | 586.757
2204451 | 462.575
2204453 | 824.659
2204457 | 1000.71
2204463 | 460.923
2204467 | 462.575
2204469 | 824.659
2204473 | 1000.71
2204479 | 460.923
2204483 | 462.575
2204485 | 824.659
2204489 | 1600.71
2204495 | 460.923
2204499 | 462.575
2204501 | 824.659
2204505 | 1600.71
2204511 | 460.923
2204515 | 462.575
2204517 | 925.474
2204521 | 1600.71
2204527 | 460.923
2204642 | 33908.1
2204648 | 1728.42
2204661 | 24260
2204663 | 21104
2204670 | 339
2205610 | 3891.46
2205721 | 2731.6
2221946 | 270
2221948 | 474.914
2221951 | 473.086
2221960 | 320
2221962 | 474.226
2221965 | 473.774
2222357 | 6758.36
2224507 | 1828.98
2507538 | 153.441
2507702 | 3580.53
2508274 | 2255.4
2518808 | 707.107
2518835 | 363.73
2564738 | 24106
2566850 | 26099
2567144 | 980.205
2567537 | 4200

# IfcFlowSegment: Round Duct:Sirkulær kanal PVC (18)
In: 0-Havnivå
Type - Description: Sirkulær kanal, PVC; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal PVC; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal PVC:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2204298 | 1913.4 | 3600.001.08 Spesialavtrekk: 21
2204306 | 1208.62 | 3600.001.05 Avtrekk: 7
2204310 | 1202.52 | 3600.001.05 Avtrekk: 7
2204697 | 2847.39 | 3600.001.05 Avtrekk: 7
2204715 | 2635.9 | 3600.001.05 Avtrekk: 7
2234510 | 1253.59 | 3600.001.05 Avtrekk: 7
2234519 | 1085 | 3600.001.05 Avtrekk: 7
2234528 | 1028.81 | 3600.001.08 Spesialavtrekk: 21
2522829 | 1762.51 | 3600.001.05 Avtrekk: 7
2528400 | 522.142 | 3600.001.05 Avtrekk: 7
2528403 | 93 | 3600.001.05 Avtrekk: 7
2528530 | 729.988 | 3600.001.05 Avtrekk: 7
2528533 | 151.564 | 3600.001.05 Avtrekk: 7
2562068 | 456.06 | 3600.001.05 Avtrekk: 7
2571729 | 1020 | 3600.001.05 Avtrekk: 7
2571732 | 1694.78 | 3600.001.05 Avtrekk: 7
2572035 | 738.616 | 3600.001.05 Avtrekk: 7
2572038 | 258.619 | 3600.001.05 Avtrekk: 7

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (95)
In: 0-Havnivå
Type - Description: Sirkulær kanal syrefast; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal SF 1; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2204039 | 594.698 | 3600.001.05 Avtrekk: 7
