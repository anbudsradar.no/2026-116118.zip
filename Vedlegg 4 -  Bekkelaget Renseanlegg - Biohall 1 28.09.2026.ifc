Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c04e82b7-d741-4bb0-b665-850c62e824b8, VersionGUID: 0e62efc3-157c-450f-8d85-b250ddbc97cd, NumberOfSaves: 1595], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Bekkelaget Renseanlegg - Biohall 1.ifc
Time: 2026-07-02T14:14:16+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENU) - 26.4.10.8

# IfcProject, 52502296
LongName: Bekkelaget RA - Oppgradering 2000-anlegget; Phase: ---

# IfcSite, Default
RefLatitude: 49, 0, 24, 428900; RefLongitude: 9, 7, 59, 338362; RefElevation: 0 mm

# IfcBuilding, Bygning (endres i Project Information)
LongName: Bygning (endres i Project Information)
Pset_BuildingCommon - NumberOfStoreys: 11

# IfcBuildingStorey (11)
In: Bygning (endres i Project Information)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
+00,00 | +00,00 | -8.84387e-11
Plan 01 | Plan 01 | 0
0-Havnivå | 0-Havnivå | 0
PLAN +2,50 | PLAN +2,50 | 2500
Plan 02 | Plan 02 | 3500
PLAN +5,00 | PLAN +5,00 | 5000
Plan 03 | Plan 03 | 7000
PLAN +7,80 | PLAN +7,80 | 7800
PLAN +10,50 | PLAN +10,50 | 10500
PLAN +13,40 | PLAN +13,40 | 13400
PLAN +16,00 | PLAN +16,00 | 16000

# IfcBuildingElementProxy: CRMc:Reuleringsspjeld - PVC ø500 (2)
In: 0-Havnivå
Type - Description: Reuleringsspjeld med muffe - PVC ø500; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: Reuleringsspjeld - PVC ø500; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (CRMc:Reuleringsspjeld - PVC ø500:...)
2220042
2220118

# IfcBuildingElementProxy: DRU:DRU 250, DRU:DRU 250:2553451
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 250; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: DRU:DRU 400 (11)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, perforert blad; Material: 3600.001 Spesialavtrekk
Pset_BuildingElementProxyCommon - Reference: DRU 400; sets with these values: 2
Name (DRU:DRU 400:...) | Group
2219876 | 3600.001.08 Spesialavtrekk: 20
2219889 | 3600.001.08 Spesialavtrekk: 20
2219901 | 3600.001.08 Spesialavtrekk: 20
2219906 | 3600.001.08 Spesialavtrekk: 20
2219931 | 3600.001.08 Spesialavtrekk: 20
2219936 | 3600.001.08 Spesialavtrekk: 20
2219941 | 3600.001.08 Spesialavtrekk: 20
2219946 | 3600.001.08 Spesialavtrekk: 20
2220198 | 3600.001.05 Avtrekk: 7
2220203 | 3600.001.05 Avtrekk: 7
2220208 | 3600.001.08 Spesialavtrekk: 20

# IfcBuildingElementProxy: IRIS:IRIS-250 (5)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-250; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (IRIS:IRIS-250:...)
2152571
2456225
2456252
2456284
2456313

# IfcBuildingElementProxy: IRIS:IRIS-315 2 (20)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: IRIS-315 2; sets with these values: 2
Name (IRIS:IRIS-315 2:...) | Group
2152611 | 3600.001.04 Tilluft: 8
2152621 | 3600.001.04 Tilluft: 8
2152631 | 3600.001.04 Tilluft: 8
2152641 | 3600.001.04 Tilluft: 8
2211233 | 3600.001.04 Tilluft: 8
2211236 | 3600.001.04 Tilluft: 8
2211239 | 3600.001.04 Tilluft: 8
2211242 | 3600.001.04 Tilluft: 8
2211245 | 3600.001.04 Tilluft: 8
2211259 | 3600.001.04 Tilluft: 8
2211273 | 3600.001.04 Tilluft: 8
2211287 | 3600.001.04 Tilluft: 8
2211301 | 3600.001.04 Tilluft: 8
2211315 | 3600.001.04 Tilluft: 8
2212158 | 3600.001.05 Avtrekk: 7
2220952 | 3600.001.04 Tilluft: 8
2220974 | 3600.001.04 Tilluft: 8
2476844 | 3600.001.05 Avtrekk: 7
2476903 | 3600.001.05 Avtrekk: 7
2476960 | 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: IRIS:IRIS-500 2 (4)
In: 0-Havnivå
Type - Description: Reguleringsspjeld, iris; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: IRIS-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (IRIS:IRIS-500 2:...)
2212152
2212155
2212176
2212179

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500, LKR-1500:LKR-1000-1500:2454574
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Avtrekk
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcBuildingElementProxy: LKR-1500:LKR-1000-1500, LKR-1500:LKR-1000-1500:2211175
In: 0-Havnivå
Type - Description: Sirkulær lyddemper; Material: 3600.001 Tilluft
Pset_BuildingElementProxyCommon - Reference: LKR-1000-1500; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcBuildingElementProxy: Toposolid:Toposolid 1, Toposolid:Toposolid 1:2375663
In: Plan 01
Material: Glass
Pset_BuildingElementProxyCommon - Reference: Toposolid 1; sets with these values: 2
Pset_ProductRequirements - Name: Terrengmodell - Biohall 1 5

# IfcDistributionPort (915)
Description: Flow
Name | FlowDirection | Group
InPort_2477426_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_1997567_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_1997567_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2500607_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529087_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_1997580_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_1997580_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529336_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2478231_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_1997689_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_1997689_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562372_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_1997711_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2478231_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2226111_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_1997711_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_1997794_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2392646_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2123881_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1997794_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997794_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2001057_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997794_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139841_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997794_4 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139877_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997794_5 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139917_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997884_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2392632_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227916_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1997884_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997884_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1999390_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997884_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1999440_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997884_4 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1999489_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1997884_5 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1999538_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1998973_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219901_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1999390_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1998973_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1998992_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219876_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1999440_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1998992_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1999030_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219889_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1999489_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1999030_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1999538_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_1999046_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_1999046_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219906_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2000611_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139810_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219946_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2000611_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2000630_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219941_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2139917_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2000630_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2000670_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139813_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219931_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2000670_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2000888_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219936_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2139841_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2000888_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2001057_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219943_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219898_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2119703_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219873_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2119706_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219886_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2119709_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219903_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2119712_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2562721_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2121537_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2121537_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2480881_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456801_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2121537_3 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456765_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2121537_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456717_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2121537_5 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2123865_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2123869_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2213685_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2123865_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2123865_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227984_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2123869_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2123866_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2123866_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2123881_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2152571_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2138095_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138095_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456725_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138368_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152568_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153568_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2138700_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138700_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2153574_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138706_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2138702_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138702_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152641_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153536_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2138976_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138976_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2153542_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152631_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2138978_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138978_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2153536_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138982_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152628_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153504_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2138998_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2138998_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215278_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152621_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2139000_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2139000_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2153504_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2139004_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152618_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153472_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2139016_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2139016_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215276_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2139022_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2139018_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2139018_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152611_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2219938_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139811_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219933_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2139812_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2139877_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219928_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2152568_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152571_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152611_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152608_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152608_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2153472_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152618_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152621_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152628_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152631_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152641_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152638_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152638_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2153568_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2152898_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215421_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153603_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152898_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215276_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2152898_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153542_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215249_3 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2153574_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215249_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518227_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2154237_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2154237_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562719_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2154890_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2220208_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2512137_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2154890_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2529136_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2155005_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2155005_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220203_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2155117_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220198_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529329_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2155117_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220200_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2155426_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220195_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2155427_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220205_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2155543_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166616_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166581_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166581_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166606_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166606_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166604_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166604_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166610_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2512144_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166608_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166608_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2213687_2 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2166610_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2512141_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
Port_2166614_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 20
Port_2166618_2 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 20
InPort_2166614_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2166616_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
Port_2166618_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 20
Port_2600625_0 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 20
InPort_2211175_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2578072_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211316_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211175_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211176_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211199_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211203_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211177_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211177_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211236_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211185_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211183_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211183_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211207_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211207_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211186_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211186_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211239_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211192_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211201_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211242_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211193_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211193_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562341_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211199_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211203_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211201_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211205_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211205_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211240_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211209_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211216_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211245_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211210_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211210_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562333_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211216_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211218_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211218_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211243_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211220_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211227_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211233_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211221_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211221_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2474926_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211227_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211229_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211229_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211231_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211231_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211233_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211236_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211234_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211234_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2475022_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211239_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211237_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211237_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2475110_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211240_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211242_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211243_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211245_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211246_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211253_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211259_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211247_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211247_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2473996_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211253_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211255_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211255_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211257_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211257_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211259_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211260_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211267_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211273_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211261_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211261_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2474976_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211267_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211269_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211269_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211271_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211271_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211273_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211274_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211281_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211287_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211275_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211275_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2475064_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211281_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211283_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211283_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211285_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211285_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211287_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211288_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211295_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211301_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211289_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211289_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2475153_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211295_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211297_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211297_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211299_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211299_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211301_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211302_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211309_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211315_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211303_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211303_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562337_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211309_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211311_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211311_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211313_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211313_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211315_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562375_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2473996_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_22 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2474926_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_23 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2474976_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_24 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2475022_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_25 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2475064_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_26 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2475110_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_27 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2475153_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2211316_28 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2211934_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212179_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211981_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211934_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211936_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212176_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211979_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211936_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212177_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211938_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212174_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211939_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571139_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211940_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211940_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571137_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211940_21 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571127_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211940_22 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571131_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211940_23 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571133_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211940_24 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571135_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2481735_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211944_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211944_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211981_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211952_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211958_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2482562_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211952_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211958_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211954_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211954_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211979_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211962_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2482126_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2482229_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211962_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211964_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212010_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2482122_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211964_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211974_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211966_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211966_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212155_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2211972_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211974_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212008_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211972_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212153_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2211978_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212006_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212008_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212010_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212006_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212041_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212035_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212035_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212158_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212037_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212043_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2454558_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212037_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212039_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212041_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2394591_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212039_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212043_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212050_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212156_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212045_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2394348_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212048_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212048_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2394591_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212050_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2393866_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212072_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212058_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212058_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483164_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212060_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212079_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483106_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212060_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483060_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212062_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212062_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212152_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212064_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212072_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2454572_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212064_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212068_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483060_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483064_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212068_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212068_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2553453_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212150_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212074_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212075_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483064_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212079_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212075_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212152_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212150_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212155_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212153_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212158_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212156_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212176_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212174_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2212179_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2212177_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2213682_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2213685_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2213687_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2213682_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2215095_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221474_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221535_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215095_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2226134_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215249_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215249_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2226136_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215278_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215357_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215357_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2226134_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2215421_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2215357_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2219876_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219873_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219889_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219886_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219901_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219898_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219906_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219903_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219928_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219931_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219936_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219933_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219941_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219938_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2219943_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2219946_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2483585_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220035_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220035_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220042_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220040_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220039_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220042_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220040_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2477138_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220111_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220111_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220118_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220116_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220115_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220118_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220116_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220198_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220195_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220203_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2220200_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2220208_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2220205_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2221068_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220945_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220945_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221074_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220952_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220947_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220947_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221068_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220949_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220950_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220950_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220952_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221531_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220967_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220967_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221535_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220974_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220969_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220969_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221531_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220971_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220972_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2220972_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2220974_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221074_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221458_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221458_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518231_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2221474_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2221458_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2226136_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2226108_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2226108_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2226111_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2500607_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2226994_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2226994_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529087_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2227775_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227978_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227984_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227775_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227777_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227916_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2227978_2 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2227777_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2393866_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2393858_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2393858_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2394100_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2394100_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2393870_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2393870_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2394348_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571104_6 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2454558_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571104_5 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2454572_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2587801_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2454574_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2454574_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571104_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2456225_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456220_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456220_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456772_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456222_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456223_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456223_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456225_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456252_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456247_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456247_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456807_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456249_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456250_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456250_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456252_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456284_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456279_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456279_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456842_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456281_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456282_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456282_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456284_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456313_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456308_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456308_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456880_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456310_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456311_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456311_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456313_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456701_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456720_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456725_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456701_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456715_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456717_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456720_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456715_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456752_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456767_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456772_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456752_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456763_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456765_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456767_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456763_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456788_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456803_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456807_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456788_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456799_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456801_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456803_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456799_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456823_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456838_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456842_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456823_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456834_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562697_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456838_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456834_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456858_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456876_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456880_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456858_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456871_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456873_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456876_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2456871_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2456873_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562595_4 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2457792_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2477138_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2477142_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2457792_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2472484_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483585_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2481259_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2472484_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476833_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476827_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476827_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476844_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476829_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476835_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476857_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476829_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476831_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476833_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476855_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476831_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476835_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476840_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476842_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476837_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476853_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476838_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476838_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476855_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476840_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476847_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476844_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476842_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476847_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476845_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476845_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476851_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476851_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476849_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476849_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476853_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571104_4 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476857_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476892_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476886_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476886_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476903_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476888_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476894_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476916_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476888_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476890_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476892_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476914_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476890_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476894_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476899_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476901_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476896_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476912_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476897_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476897_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476914_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476899_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476906_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476903_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476901_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476906_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476904_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476904_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476910_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476910_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476908_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476908_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476912_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571104_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476916_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476949_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476943_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476943_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476960_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476945_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476951_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571127_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476945_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476947_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476949_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476971_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476947_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476951_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476956_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476958_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476953_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476969_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476954_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476954_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476971_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476956_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476963_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476960_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476958_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476963_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476961_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476961_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476967_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476967_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476965_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2476965_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2476969_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483582_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2477142_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2477286_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2478489_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2478419_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2477286_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571137_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2477426_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571131_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2478416_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2478416_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2478419_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2478489_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2478477_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2478477_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2479126_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2479126_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2478786_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2478786_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481263_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2479168_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479164_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2479164_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479322_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2479166_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479168_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2479172_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479166_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2479170_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479172_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2480885_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479170_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2479319_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562343_2 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2479322_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2479319_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2480881_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2480878_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2480878_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2480885_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2481256_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481259_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2481263_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481256_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2481720_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481735_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2481882_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481720_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571133_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481879_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2481879_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2481882_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2482029_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2482122_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2482126_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2482029_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571135_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2482226_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2482226_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2482229_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2571104_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2482562_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483098_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483106_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483164_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483098_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2483585_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2483582_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529140_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2500640_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529091_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2511965_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2511965_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529143_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2512144_3 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2512134_0 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2512134_1 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2512137_2 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2512141_0 | SINK | 3600.001.08 Spesialavtrekk: 20
OutPort_2512144_1 | SOURCE | 3600.001.08 Spesialavtrekk: 20
InPort_2518224_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518227_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2518231_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2518224_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2529333_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529091_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529132_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529126_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529126_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529136_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529143_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529129_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529129_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529132_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529143_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529140_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529325_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529319_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529319_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529329_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529336_3 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529322_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529322_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529325_2 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2529336_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2529333_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2553453_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2553445_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2553445_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562009_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2553451_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2553449_0 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2553449_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562013_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562007_0 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2553451_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562009_2 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2562007_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2562372_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562285_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562285_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562375_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562333_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562285_7 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562337_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562285_8 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562341_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562285_9 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562343_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562285_10 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562719_2 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562595_0 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562595_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562721_1 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2562697_1 | SINK | 3600.001.04 Tilluft: 8
OutPort_2562595_5 | SOURCE | 3600.001.04 Tilluft: 8
InPort_2571104_1 | SINK | 3600.001.05 Avtrekk: 7
OutPort_2571139_1 | SOURCE | 3600.001.05 Avtrekk: 7
InPort_2578072_0 | SINK | 3600.001.04 Tilluft: 8
OutPort_2587801_0 | SOURCE | 3600.001.05 Avtrekk: 7
Port_2600625_1 | SOURCEANDSINK | 3600.001.08 Spesialavtrekk: 20

# IfcFlowFitting: Lindab ESU:ESU, Lindab ESU:ESU:2153603
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: ESU; sets with these values: 2
Group: 3600.001.04 Tilluft: 8

# IfcFlowFitting: Lindab TCPU:TCPU (4)
In: 0-Havnivå
Type - Description: T-stykke, Sirkulær; Material: DF_Material1
Pset_DistributionFlowElementCommon - Reference: TCPU; sets with these values: 2
Name (Lindab TCPU:TCPU:...) | Group
2483585 | 3600.001.05 Avtrekk: 7
2512144 | 3600.001.08 Spesialavtrekk: 20
2529143 | 3600.001.05 Avtrekk: 7
2529336 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (53)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2211958 | 3600.001.05 Avtrekk: 7
2211974 | 3600.001.05 Avtrekk: 7
2211979 | 3600.001.05 Avtrekk: 7
2211981 | 3600.001.05 Avtrekk: 7
2212008 | 3600.001.05 Avtrekk: 7
2212010 | 3600.001.05 Avtrekk: 7
2212041 | 3600.001.05 Avtrekk: 7
2212043 | 3600.001.05 Avtrekk: 7
2212072 | 3600.001.05 Avtrekk: 7
2212079 | 3600.001.05 Avtrekk: 7
2393866 | 3600.001.05 Avtrekk: 7
2394100 | 3600.001.05 Avtrekk: 7
2394348 | 3600.001.05 Avtrekk: 7
2394591 | 3600.001.05 Avtrekk: 7
2476833 | 3600.001.05 Avtrekk: 7
2476835 | 3600.001.05 Avtrekk: 7
2476847 | 3600.001.05 Avtrekk: 7
2476851 | 3600.001.05 Avtrekk: 7
2476853 | 3600.001.05 Avtrekk: 7
2476855 | 3600.001.05 Avtrekk: 7
2476892 | 3600.001.05 Avtrekk: 7
2476894 | 3600.001.05 Avtrekk: 7
2476906 | 3600.001.05 Avtrekk: 7
2476910 | 3600.001.05 Avtrekk: 7
2476912 | 3600.001.05 Avtrekk: 7
2476914 | 3600.001.05 Avtrekk: 7
2476949 | 3600.001.05 Avtrekk: 7
2476951 | 3600.001.05 Avtrekk: 7
2476963 | 3600.001.05 Avtrekk: 7
2476967 | 3600.001.05 Avtrekk: 7
2476969 | 3600.001.05 Avtrekk: 7
2476971 | 3600.001.05 Avtrekk: 7
2477138 | 3600.001.05 Avtrekk: 7
2477426 | 3600.001.05 Avtrekk: 7
2478419 | 3600.001.05 Avtrekk: 7
2478489 | 3600.001.05 Avtrekk: 7
2479126 | 3600.001.05 Avtrekk: 7
2479168 | 3600.001.04 Tilluft: 8
2479172 | 3600.001.04 Tilluft: 8
2479322 | 3600.001.04 Tilluft: 8
2481263 | 3600.001.05 Avtrekk: 7
2481735 | 3600.001.05 Avtrekk: 7
2481882 | 3600.001.05 Avtrekk: 7
2482122 | 3600.001.05 Avtrekk: 7
2482126 | 3600.001.05 Avtrekk: 7
2482229 | 3600.001.05 Avtrekk: 7
2483060 | 3600.001.05 Avtrekk: 7
2483064 | 3600.001.05 Avtrekk: 7
2483106 | 3600.001.05 Avtrekk: 7
2483164 | 3600.001.05 Avtrekk: 7
2500607 | 3600.001.05 Avtrekk: 7
2529087 | 3600.001.05 Avtrekk: 7
2562009 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (13)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...) | Group
2123869 | 3600.001.08 Spesialavtrekk: 20
2123881 | 3600.001.08 Spesialavtrekk: 20
2213685 | 3600.001.08 Spesialavtrekk: 20
2213687 | 3600.001.08 Spesialavtrekk: 20
2227916 | 3600.001.08 Spesialavtrekk: 20
2227978 | 3600.001.08 Spesialavtrekk: 20
2480881 | 3600.001.04 Tilluft: 8
2481259 | 3600.001.05 Avtrekk: 7
2512137 | 3600.001.08 Spesialavtrekk: 20
2529132 | 3600.001.05 Avtrekk: 7
2529136 | 3600.001.05 Avtrekk: 7
2529325 | 3600.001.05 Avtrekk: 7
2529329 | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 (13)
In: 0-Havnivå
Type - Description: Bend, Sirkulær; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001:...)
2456720
2456725
2456767
2456772
2456803
2456807
2456838
2456842
2456876
2456880
2480885
2518227
2518231

# IfcFlowFitting: magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv (20)
In: 0-Havnivå
Type - Description: Bend, Sirkulær Galv; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_full_radius_001 Galv; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_elbow_full_radius_001:magicirc_elbow_full_radius_001 Galv:...)
2153472
2153504
2153536
2153568
2211203
2211205
2211207
2211218
2211229
2211255
2211269
2211283
2211297
2211311
2221068
2221531
2221535
2226111
2226136
2478231

# IfcFlowFitting: magicirc_elbow_short_1:magicirc_elbow_short_001 (2)
In: PLAN +10,50
Type - Description: Circular,smooth, minimum radius; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_elbow_short_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (magicirc_elbow_short_1:magicirc_elbow_short_001:...)
2166606
2166610

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001, magicirc_plug_001:magicirc_plug_001:2500640
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_plug_001:magicirc_plug_001 (2)
In: 0-Havnivå
Type - Description: Endelokk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_plug_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (magicirc_plug_001:magicirc_plug_001:...)
2392632
2392646

# IfcFlowFitting: magicirc_reduction_001:magicirc_reduction_001 (12)
Type - Description: Overgang, Sirkulær; Material: Material_Duct
Pset_DistributionFlowElementCommon - Reference: magicirc_reduction_001; sets with these values: 2
Name (magicirc_reduction_001:magicirc_reduction_001:...) | In | Group
2166618 | PLAN +10,50 | 3600.001.08 Spesialavtrekk: 20
2215421 | 0-Havnivå | 3600.001.04 Tilluft: 8
2221474 | 0-Havnivå | 3600.001.04 Tilluft: 8
2226134 | 0-Havnivå | 3600.001.04 Tilluft: 8
2477142 | 0-Havnivå | 3600.001.05 Avtrekk: 7
2529091 | 0-Havnivå | 3600.001.05 Avtrekk: 7
2562372 | 0-Havnivå | 3600.001.04 Tilluft: 8
2562375 | 0-Havnivå | 3600.001.04 Tilluft: 8
2562719 | 0-Havnivå | 3600.001.04 Tilluft: 8
2562721 | 0-Havnivå | 3600.001.04 Tilluft: 8
2571137 | 0-Havnivå | 3600.001.05 Avtrekk: 7
2571139 | 0-Havnivå | 3600.001.05 Avtrekk: 7

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (10)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2454558
2454572
2476857
2476916
2482562
2553453
2571127
2571131
2571133
2571135

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (10)
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...) | In
1999390 | 0-Havnivå
1999440 | 0-Havnivå
1999489 | 0-Havnivå
1999538 | 0-Havnivå
2001057 | 0-Havnivå
2139841 | 0-Havnivå
2139877 | 0-Havnivå
2139917 | 0-Havnivå
2166616 | PLAN +10,50
2227984 | 0-Havnivå

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (21)
In: 0-Havnivå
Type - Description: Påstikk, Sirkulær; Material: 3600.001 Tilluft
