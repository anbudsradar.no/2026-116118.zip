Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowFitting: magicirc_tapoutlet_001:magicirc_tapoutlet_001 (21)
Pset_DistributionFlowElementCommon - Reference: magicirc_tapoutlet_001; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (magicirc_tapoutlet_001:magicirc_tapoutlet_001:...)
2153542
2153574
2215276
2215278
2221074
2456717
2456765
2456801
2456873
2473996
2474926
2474976
2475022
2475064
2475110
2475153
2562333
2562337
2562341
2562343
2562697

# IfcFlowSegment: Round Duct:Sirkulær kanal Galv (92)
In: 0-Havnivå
Type - Description: Sirkulær kanal, Galvanisert stål; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal Galv; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal Galv:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1997689 | 795.507 | 3600.001.04 Tilluft: 8
1997711 | 5018.76 | 3600.001.04 Tilluft: 8
2121537 | 34433.8 | 3600.001.04 Tilluft: 8
2138095 | 231.766 | 3600.001.04 Tilluft: 8
2138700 | 74.9994 | 3600.001.04 Tilluft: 8
2138702 | 520.302 | 3600.001.04 Tilluft: 8
2138976 | 75 | 3600.001.04 Tilluft: 8
2138978 | 478.893 | 3600.001.04 Tilluft: 8
2138998 | 125 | 3600.001.04 Tilluft: 8
2139000 | 481.243 | 3600.001.04 Tilluft: 8
2139016 | 167.5 | 3600.001.04 Tilluft: 8
2139018 | 475.771 | 3600.001.04 Tilluft: 8
2152568 | 466.234 | 3600.001.04 Tilluft: 8
2152608 | 472.229 | 3600.001.04 Tilluft: 8
2152618 | 466.757 | 3600.001.04 Tilluft: 8
2152628 | 469.107 | 3600.001.04 Tilluft: 8
2152638 | 467.698 | 3600.001.04 Tilluft: 8
2152898 | 17464.5 | 3600.001.04 Tilluft: 8
2154237 | 4546.81 | 3600.001.04 Tilluft: 8
2211177 | 300.92 | 3600.001.04 Tilluft: 8
2211183 | 1600.7 | 3600.001.04 Tilluft: 8
2211186 | 300.918 | 3600.001.04 Tilluft: 8
2211193 | 402.504 | 3600.001.04 Tilluft: 8
2211199 | 1000.7 | 3600.001.04 Tilluft: 8
2211201 | 1600.71 | 3600.001.04 Tilluft: 8
2211210 | 402.506 | 3600.001.04 Tilluft: 8
2211216 | 1600.71 | 3600.001.04 Tilluft: 8
2211221 | 302.497 | 3600.001.04 Tilluft: 8
2211227 | 1000.71 | 3600.001.04 Tilluft: 8
2211231 | 300.922 | 3600.001.04 Tilluft: 8
2211234 | 302.499 | 3600.001.04 Tilluft: 8
2211237 | 302.502 | 3600.001.04 Tilluft: 8
2211240 | 300.916 | 3600.001.04 Tilluft: 8
2211243 | 300.914 | 3600.001.04 Tilluft: 8
2211247 | 286.795 | 3600.001.04 Tilluft: 8
2211253 | 1000.71 | 3600.001.04 Tilluft: 8
2211257 | 300.923 | 3600.001.04 Tilluft: 8
2211261 | 302.498 | 3600.001.04 Tilluft: 8
2211267 | 1000.71 | 3600.001.04 Tilluft: 8
2211271 | 300.921 | 3600.001.04 Tilluft: 8
2211275 | 302.5 | 3600.001.04 Tilluft: 8
2211281 | 1600.71 | 3600.001.04 Tilluft: 8
2211285 | 300.919 | 3600.001.04 Tilluft: 8
2211289 | 302.503 | 3600.001.04 Tilluft: 8
2211295 | 1600.71 | 3600.001.04 Tilluft: 8
2211299 | 300.917 | 3600.001.04 Tilluft: 8
2211303 | 402.505 | 3600.001.04 Tilluft: 8
2211309 | 1600.71 | 3600.001.04 Tilluft: 8
2211313 | 300.915 | 3600.001.04 Tilluft: 8
2211316 | 46451.1 | 3600.001.04 Tilluft: 8
2215095 | 5281.89 | 3600.001.04 Tilluft: 8
2215249 | 28200 | 3600.001.04 Tilluft: 8
2215357 | 16700 | 3600.001.04 Tilluft: 8
2220945 | 185 | 3600.001.04 Tilluft: 8
2220947 | 474.914 | 3600.001.04 Tilluft: 8
2220950 | 473.086 | 3600.001.04 Tilluft: 8
2220967 | 90 | 3600.001.04 Tilluft: 8
2220969 | 474.226 | 3600.001.04 Tilluft: 8
2220972 | 473.774 | 3600.001.04 Tilluft: 8
2221458 | 3000 | 3600.001.04 Tilluft: 8
2226108 | 2166.03 | 3600.001.04 Tilluft: 8
2456220 | 231.766 | 3600.001.04 Tilluft: 8
2456223 | 466.234 | 3600.001.04 Tilluft: 8
2456247 | 351.766 | 3600.001.04 Tilluft: 8
2456250 | 466.234 | 3600.001.04 Tilluft: 8
2456279 | 231.766 | 3600.001.04 Tilluft: 8
2456282 | 466.234 | 3600.001.04 Tilluft: 8
2456308 | 231.766 | 3600.001.04 Tilluft: 8
2456311 | 466.234 | 3600.001.04 Tilluft: 8
2456701 | 340.001 | 3600.001.04 Tilluft: 8
2456715 | 148.494 | 3600.001.04 Tilluft: 8
2456752 | 340 | 3600.001.04 Tilluft: 8
2456763 | 148.494 | 3600.001.04 Tilluft: 8
2456788 | 340 | 3600.001.04 Tilluft: 8
2456799 | 148.494 | 3600.001.04 Tilluft: 8
2456823 | 340 | 3600.001.04 Tilluft: 8
2456834 | 213.754 | 3600.001.04 Tilluft: 8
2456858 | 340 | 3600.001.04 Tilluft: 8
2456871 | 213.754 | 3600.001.04 Tilluft: 8
2477286 | 2121.5 | 3600.001.05 Avtrekk: 7
2478416 | 455.035 | 3600.001.05 Avtrekk: 7
2478477 | 4071.84 | 3600.001.05 Avtrekk: 7
2478786 | 927.274 | 3600.001.05 Avtrekk: 7
2479164 | 971.125 | 3600.001.04 Tilluft: 8
2479166 | 4071.84 | 3600.001.04 Tilluft: 8
2479170 | 1385.1 | 3600.001.04 Tilluft: 8
2479319 | 455.035 | 3600.001.04 Tilluft: 8
2480878 | 2204.55 | 3600.001.04 Tilluft: 8
2518224 | 1131.37 | 3600.001.04 Tilluft: 8
2562285 | 22162.5 | 3600.001.04 Tilluft: 8
2562595 | 28539.5 | 3600.001.04 Tilluft: 8
2578072 | 1094 | 3600.001.04 Tilluft: 8

# IfcFlowSegment: Round Duct:Sirkulær kanal PVC (17)
In: 0-Havnivå
Type - Description: Sirkulær kanal, PVC; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal PVC; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal PVC:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2154890 | 1687.55 | 3600.001.08 Spesialavtrekk: 20
2155005 | 629.257 | 3600.001.05 Avtrekk: 7
2155117 | 714.481 | 3600.001.05 Avtrekk: 7
2220035 | 1362.85 | 3600.001.05 Avtrekk: 7
2220040 | 711.043 | 3600.001.05 Avtrekk: 7
2220111 | 1242.85 | 3600.001.05 Avtrekk: 7
2220116 | 671.043 | 3600.001.05 Avtrekk: 7
2220195 | 1015.12 | 3600.001.05 Avtrekk: 7
2220200 | 1015.12 | 3600.001.05 Avtrekk: 7
2220205 | 1180.83 | 3600.001.08 Spesialavtrekk: 20
2512134 | 1342.65 | 3600.001.08 Spesialavtrekk: 20
2529126 | 343.923 | 3600.001.05 Avtrekk: 7
2529129 | 264.714 | 3600.001.05 Avtrekk: 7
2529319 | 402.15 | 3600.001.05 Avtrekk: 7
2529322 | 100.376 | 3600.001.05 Avtrekk: 7
2553449 | 1020 | 3600.001.05 Avtrekk: 7
2562007 | 1617.77 | 3600.001.05 Avtrekk: 7

# IfcFlowSegment: Round Duct:Sirkulær kanal SF 1 (100)
In: 0-Havnivå
Type - Description: Sirkulær kanal syrefast; Material: 3600.001 Avtrekk
Pset_DistributionFlowElementCommon - Reference: Sirkulær kanal SF 1; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Sirkulær kanal SF 1:...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1997567 | 4251.6 | 3600.001.05 Avtrekk: 7
1997580 | 43623 | 3600.001.05 Avtrekk: 7
1997794 | 33315.2 | 3600.001.08 Spesialavtrekk: 20
1997884 | 39284.1 | 3600.001.08 Spesialavtrekk: 20
1998973 | 735.375 | 3600.001.08 Spesialavtrekk: 20
1998992 | 782.506 | 3600.001.08 Spesialavtrekk: 20
1999030 | 763.271 | 3600.001.08 Spesialavtrekk: 20
1999046 | 760.425 | 3600.001.08 Spesialavtrekk: 20
2000611 | 798.859 | 3600.001.08 Spesialavtrekk: 20
2000630 | 797.583 | 3600.001.08 Spesialavtrekk: 20
2000670 | 742.76 | 3600.001.08 Spesialavtrekk: 20
2000888 | 834.982 | 3600.001.08 Spesialavtrekk: 20
2123865 | 25430.8 | 3600.001.08 Spesialavtrekk: 20
2123866 | 698.699 | 3600.001.08 Spesialavtrekk: 20
2166581 | 3386.61 | 3600.001.08 Spesialavtrekk: 20
2166604 | 1456.84 | 3600.001.08 Spesialavtrekk: 20
2166608 | 503.274 | 3600.001.08 Spesialavtrekk: 20
2166614 | 35159.1 | 3600.001.08 Spesialavtrekk: 20
2211934 | 777.787 | 3600.001.05 Avtrekk: 7
2211936 | 638.793 | 3600.001.05 Avtrekk: 7
2211940 | 22250 | 3600.001.05 Avtrekk: 7
2211944 | 4130.47 | 3600.001.05 Avtrekk: 7
2211952 | 3714.15 | 3600.001.05 Avtrekk: 7
2211954 | 5126.46 | 3600.001.05 Avtrekk: 7
2211962 | 2944.78 | 3600.001.05 Avtrekk: 7
2211964 | 1144.77 | 3600.001.05 Avtrekk: 7
2211966 | 1406.59 | 3600.001.05 Avtrekk: 7
2211972 | 1546.03 | 3600.001.05 Avtrekk: 7
2212006 | 85.1682 | 3600.001.05 Avtrekk: 7
2212035 | 706.124 | 3600.001.05 Avtrekk: 7
2212037 | 50.1577 | 3600.001.05 Avtrekk: 7
2212039 | 285.323 | 3600.001.05 Avtrekk: 7
2212048 | 2163.41 | 3600.001.05 Avtrekk: 7
2212050 | 4466.17 | 3600.001.05 Avtrekk: 7
2212058 | 3193.47 | 3600.001.05 Avtrekk: 7
2212060 | 1719.9 | 3600.001.05 Avtrekk: 7
2212062 | 1181.9 | 3600.001.05 Avtrekk: 7
2212064 | 25.1577 | 3600.001.05 Avtrekk: 7
2212068 | 823.687 | 3600.001.05 Avtrekk: 7
2212075 | 2295.29 | 3600.001.05 Avtrekk: 7
2212150 | 922.844 | 3600.001.05 Avtrekk: 7
2212153 | 1193.61 | 3600.001.05 Avtrekk: 7
2212156 | 758.846 | 3600.001.05 Avtrekk: 7
2212174 | 916.743 | 3600.001.05 Avtrekk: 7
2212177 | 984.589 | 3600.001.05 Avtrekk: 7
2213682 | 811.074 | 3600.001.08 Spesialavtrekk: 20
2219873 | 682.494 | 3600.001.08 Spesialavtrekk: 20
2219886 | 701.729 | 3600.001.08 Spesialavtrekk: 20
2219898 | 729.625 | 3600.001.08 Spesialavtrekk: 20
2219903 | 704.575 | 3600.001.08 Spesialavtrekk: 20
2219928 | 722.784 | 3600.001.08 Spesialavtrekk: 20
2219933 | 630.562 | 3600.001.08 Spesialavtrekk: 20
2219938 | 667.961 | 3600.001.08 Spesialavtrekk: 20
2219943 | 666.685 | 3600.001.08 Spesialavtrekk: 20
2226994 | 2366.03 | 3600.001.05 Avtrekk: 7
2227775 | 12413.5 | 3600.001.08 Spesialavtrekk: 20
2227777 | 927.392 | 3600.001.08 Spesialavtrekk: 20
2393858 | 1810.24 | 3600.001.05 Avtrekk: 7
2393870 | 1913.41 | 3600.001.05 Avtrekk: 7
2457792 | 22524 | 3600.001.05 Avtrekk: 7
2472484 | 41395.2 | 3600.001.05 Avtrekk: 7
2476827 | 706.124 | 3600.001.05 Avtrekk: 7
2476829 | 50.1577 | 3600.001.05 Avtrekk: 7
2476831 | 285.323 | 3600.001.05 Avtrekk: 7
2476838 | 2163.41 | 3600.001.05 Avtrekk: 7
2476840 | 4466.17 | 3600.001.05 Avtrekk: 7
2476842 | 758.846 | 3600.001.05 Avtrekk: 7
2476845 | 1810.24 | 3600.001.05 Avtrekk: 7
2476849 | 1913.41 | 3600.001.05 Avtrekk: 7
2476886 | 706.124 | 3600.001.05 Avtrekk: 7
2476888 | 50.1577 | 3600.001.05 Avtrekk: 7
2476890 | 285.323 | 3600.001.05 Avtrekk: 7
2476897 | 2163.41 | 3600.001.05 Avtrekk: 7
2476899 | 4466.17 | 3600.001.05 Avtrekk: 7
2476901 | 758.846 | 3600.001.05 Avtrekk: 7
2476904 | 1810.24 | 3600.001.05 Avtrekk: 7
2476908 | 1913.41 | 3600.001.05 Avtrekk: 7
2476943 | 706.124 | 3600.001.05 Avtrekk: 7
2476945 | 150.158 | 3600.001.05 Avtrekk: 7
2476947 | 285.323 | 3600.001.05 Avtrekk: 7
2476954 | 2163.41 | 3600.001.05 Avtrekk: 7
2476956 | 4466.17 | 3600.001.05 Avtrekk: 7
2476958 | 758.846 | 3600.001.05 Avtrekk: 7
2476961 | 1810.24 | 3600.001.05 Avtrekk: 7
2476965 | 1913.41 | 3600.001.05 Avtrekk: 7
2481256 | 2623.57 | 3600.001.05 Avtrekk: 7
2481720 | 519.119 | 3600.001.05 Avtrekk: 7
2481879 | 3775.27 | 3600.001.05 Avtrekk: 7
2482029 | 5391.26 | 3600.001.05 Avtrekk: 7
2482226 | 359.605 | 3600.001.05 Avtrekk: 7
2483098 | 3906.53 | 3600.001.05 Avtrekk: 7
2483582 | 1084 | 3600.001.05 Avtrekk: 7
2511965 | 17052.5 | 3600.001.05 Avtrekk: 7
2512141 | 163.218 | 3600.001.08 Spesialavtrekk: 20
2529140 | 814.423 | 3600.001.05 Avtrekk: 7
2529333 | 600 | 3600.001.05 Avtrekk: 7
2553445 | 736.131 | 3600.001.05 Avtrekk: 7
2571104 | 46465.4 | 3600.001.05 Avtrekk: 7
2587801 | 1090 | 3600.001.05 Avtrekk: 7
2600625 | 5400 | 3600.001.08 Spesialavtrekk: 20

# IfcFlowTerminal: Netting-A:Netting-A-250 2, Netting-A:Netting-A-250 2:2562013
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-250 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7

# IfcFlowTerminal: Netting-A:Netting-A-315 2 (4)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-315 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-315 2:...)
2212045
2476837
2476896
2476953

# IfcFlowTerminal: Netting-A:Netting-A-400 2 (3)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-400 2; sets with these values: 2
Name (Netting-A:Netting-A-400 2:...) | Group
2155426 | 3600.001.05 Avtrekk: 7
2155427 | 3600.001.05 Avtrekk: 7
2155543 | 3600.001.08 Spesialavtrekk: 20

# IfcFlowTerminal: Netting-A:Netting-A-500 2 (6)
In: 0-Havnivå
Type - Description: Nettingrist; Material: MC_140_140_140_0_50, MC_163_163_163_0_50
Pset_DistributionFlowElementCommon - Reference: Netting-A-500 2; sets with these values: 2
Group: 3600.001.05 Avtrekk: 7
Name (Netting-A:Netting-A-500 2:...)
2211938
2211939
2211978
2212074
2220039
2220115

# IfcFlowTerminal: SI-T_V:SI-T/V-0618 (5)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-0618; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-0618:...)
2138368
2456222
2456249
2456281
2456310

# IfcFlowTerminal: SI-T_V:SI-T/V-1212 (7)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1212; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1212:...)
2138706
2211185
2211192
2211209
2211274
2211288
2211302

# IfcFlowTerminal: SI-T_V:SI-T/V-1218 (9)
In: 0-Havnivå
Type - Description: ATD for displacement ventilation; Material: 3600.001 Tilluft
Pset_DistributionFlowElementCommon - Reference: SI-T/V-1218; sets with these values: 2
Group: 3600.001.04 Tilluft: 8
Name (SI-T_V:SI-T/V-1218:...)
2138982
2139004
2139022
2211176
2211220
2211246
2211260
2220949
2220971

# IfcFlowTerminal: UPK-H-K-B-400:UPK-H-K-B-400 (8)
In: 0-Havnivå
Type - Description: Exhaust diffusor; Material: 3600.001 Spesialavtrekk
Pset_DistributionFlowElementCommon - Reference: UPK-H-K-B-400; sets with these values: 2
Group: 3600.001.08 Spesialavtrekk: 20
Name (UPK-H-K-B-400:UPK-H-K-B-400:...)
2119703
2119706
2119709
2119712
2139810
2139811
2139812
2139813
